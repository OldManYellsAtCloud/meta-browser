# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae0b7c93cbcf02a6c0a49468f6563dff"
SRC_URI[sha256sum] = "307625501a43d8e0de237725581a4fec20e38fe28da73094707e4876e05a06bc"
