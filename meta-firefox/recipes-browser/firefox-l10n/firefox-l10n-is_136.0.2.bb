# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df11c1f29a6cfdf81b8c59bd22e0ee50"
SRC_URI[sha256sum] = "5eda586bae75ac1276011a27c9267f25281c9b05fd4f28ed63db7d93d63814ef"
