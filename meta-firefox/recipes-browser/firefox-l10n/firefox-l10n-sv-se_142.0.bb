# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3236686076f803b75d3ea75980c49fbc"
SRC_URI[sha256sum] = "f3cb92d5d671a47154766294a117e585de7befe83402b2bc8386a42ff4a3c939"
