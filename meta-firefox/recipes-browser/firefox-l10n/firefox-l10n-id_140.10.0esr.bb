# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6e29d5dcf18d531a4f1acda5e1f7472728aaf274e120f063795978ccd5e20fe3"
