# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6416641ba144d2ff3b32f1be9b9544d9"
SRC_URI[sha256sum] = "dd02aa12c06c6e898290ae8f2b3ba232a1d6bcc75f04ea4b2af95cfcf381c682"
