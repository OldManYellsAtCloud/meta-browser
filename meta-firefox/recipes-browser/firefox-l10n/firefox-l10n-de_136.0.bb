# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d5af98cced301ba3a474b02d46455df"
SRC_URI[sha256sum] = "054ad7cf4a57f5c3706b796ac153a96bed1aeaf1222e8d830251a42100b6ffb7"
