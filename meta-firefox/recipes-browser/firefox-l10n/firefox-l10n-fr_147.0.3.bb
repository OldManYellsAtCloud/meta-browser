# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2f4944bda89d67b4fda76e76e28dc62"
SRC_URI[sha256sum] = "67f56a609118308bc3992eab17494604c8e466322be1ad5cfe31db2d267b1c07"
