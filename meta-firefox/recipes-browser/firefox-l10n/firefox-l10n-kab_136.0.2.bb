# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48a26babec194e94dab1debc1f1ee6d8"
SRC_URI[sha256sum] = "70f31a0ada8f90b2a53442da11e86413b24d459d8d879b82f409e866628e9434"
