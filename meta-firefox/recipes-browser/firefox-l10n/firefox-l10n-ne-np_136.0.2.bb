# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7a60be068f8223063328bd06e0c737d"
SRC_URI[sha256sum] = "17f562660449d54882de639b46d874c8839de15e3b751308b6146b93e135161a"
