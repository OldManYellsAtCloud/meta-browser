# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6899b25b646dc45d548f72ea99382854"
SRC_URI[sha256sum] = "2e6619caaa505bcbaead4a7d9a52d8b6d636271273363e29726343c9a9cfcc03"
