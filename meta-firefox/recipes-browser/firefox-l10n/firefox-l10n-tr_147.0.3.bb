# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b03368fee1f49b8932285bcf156f8db"
SRC_URI[sha256sum] = "85a043a5e234d97edd1ea6327878a7155b29384a374b4fbc594d9569e541940f"
