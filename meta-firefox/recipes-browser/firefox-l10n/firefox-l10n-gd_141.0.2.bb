# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24d940c6c08a4d4c2b96c2cb874c1753"
SRC_URI[sha256sum] = "4b1f454ef746a27aee9e1cb73a385809c2f642fc2ca2d1e64c33a7a17d369255"
