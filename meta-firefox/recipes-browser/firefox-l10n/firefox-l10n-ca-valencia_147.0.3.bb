# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2098f14124c567105c6f76db005740c"
SRC_URI[sha256sum] = "bf9c14f07af782c5a18d086ec7ff75296340736255390804f9475aef81480282"
