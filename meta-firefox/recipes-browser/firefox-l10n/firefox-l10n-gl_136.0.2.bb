# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f860cd10d63e17faae7763694d87c9d6"
SRC_URI[sha256sum] = "d34c1599ff24c276c0b3ef3992d8c98a454c858e8b37a845796f9de74a587758"
