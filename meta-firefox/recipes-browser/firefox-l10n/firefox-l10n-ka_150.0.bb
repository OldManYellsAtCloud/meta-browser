# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "561d153bfa2646753728302e00ae99f8be225e3c5c6e3423796afb66d1597cd3"
