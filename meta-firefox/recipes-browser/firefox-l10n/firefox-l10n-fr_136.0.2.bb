# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f707291a798ac3e7f0d60f7125b2aa0b"
SRC_URI[sha256sum] = "dc3c3274cc1dd5d76ca6bab255cd73d40f9a205d8825e03243b099d7a67fc914"
