# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa130b21eae967977648a025eb9216e7"
SRC_URI[sha256sum] = "5361974ebb0a6bbc33653e4910c0911086e6b6e4f187321f6bf607870845ee2b"
