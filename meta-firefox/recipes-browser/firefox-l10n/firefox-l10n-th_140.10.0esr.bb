# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "50576b99ae78a356d15490611a66494597b5f229e8d8dc5fa3ab98c6f6fbaa5e"
