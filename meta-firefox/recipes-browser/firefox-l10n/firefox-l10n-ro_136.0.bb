# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ec9d237181643938783379b7ebf2052"
SRC_URI[sha256sum] = "69d8e62b5755465c1692ec1c174a295b900a3bb8eec35b0820362d9b7999c479"
