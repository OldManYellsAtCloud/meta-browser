# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7db651de6c101a84258b01413522fd2b"
SRC_URI[sha256sum] = "a09af68fb61f2c0edebcb2af1aff1f1751c15a75d136916642c0840ecab0ff7b"
