# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f2920e26576ad946ae63b989b652ac0"
SRC_URI[sha256sum] = "49c6d5b516da7862e64b6f5b8a61dd5a2f0669826f73bf89f2664e5327889be6"
