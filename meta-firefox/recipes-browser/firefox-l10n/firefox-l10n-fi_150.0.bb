# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f195070a515bd881ae52ae9d56574d4272eafba2b10ba87c42dfc795cd5b4764"
