# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05a19f59a09e76282d176d8850e120b3"
SRC_URI[sha256sum] = "f511d033e7821ece8878f0f13b315a1cff8ef501ae3f417a851867ab09b8a01f"
