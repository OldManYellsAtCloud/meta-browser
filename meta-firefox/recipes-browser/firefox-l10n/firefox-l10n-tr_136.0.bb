# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "884a55bca892621f024c0388e9917ee8"
SRC_URI[sha256sum] = "a7932b579799e1415a8721e7739c8c1cd988654ede099b7bca6c42ff74f4a2ef"
