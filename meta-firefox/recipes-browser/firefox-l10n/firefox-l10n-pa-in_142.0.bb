# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d60a5bfeaddacf2ddbee18f0ec363e7"
SRC_URI[sha256sum] = "52deb0e780b8ed8c1c7c684bf1b18b3de6502e868574dccfa6b5e35fca6cd6a7"
