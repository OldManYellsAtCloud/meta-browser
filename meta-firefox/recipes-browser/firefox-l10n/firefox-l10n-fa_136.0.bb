# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d72c486fac0dfbdf670b74bc3b695669"
SRC_URI[sha256sum] = "7b9c2b820ff6c24c3758f1708980a7880436f068dfcbf40318a6dcbc65aab82f"
