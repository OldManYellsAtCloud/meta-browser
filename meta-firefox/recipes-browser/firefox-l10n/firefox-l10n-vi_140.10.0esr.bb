# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6a062f6cbe79c072b622ea3d59395ad3865995c75527d14fbc5f38af69bc6ec9"
