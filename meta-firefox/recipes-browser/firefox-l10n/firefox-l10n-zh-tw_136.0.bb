# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6297d8853baac0204f9781053634d1f7"
SRC_URI[sha256sum] = "996cd7f84da820d69d1b020cca85df8a6dae4ad6441d9a417f4f09ce53424377"
