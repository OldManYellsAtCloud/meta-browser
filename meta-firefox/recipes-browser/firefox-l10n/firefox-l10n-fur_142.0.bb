# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36b1fb71b0f7480b67b98cba2b0f405f"
SRC_URI[sha256sum] = "c1a9db6b0e3716bc45501c3c3d55dec735d5748350fd8e33bdf6252c3b1704cd"
