# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "768c20304254a9a5f45abd03b566936a"
SRC_URI[sha256sum] = "1ff001686174de594baa0f0fd6db5b79a663c3df5805f9188a0ee6cf80469be6"
