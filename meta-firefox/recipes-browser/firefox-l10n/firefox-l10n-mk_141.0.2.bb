# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c7f958619078b8c6e9105407ca91685"
SRC_URI[sha256sum] = "aeae8bccb8e579234df21817a1dd80d7581ebf8c6782ab34c2f61b715deb4f89"
