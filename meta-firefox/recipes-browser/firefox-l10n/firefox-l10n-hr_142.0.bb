# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62e60f42887e7a6e210097632407ac84"
SRC_URI[sha256sum] = "f2fd9228b587095f1de1ac9c6858e85cfaf966280081d64c1cf9ffd247582105"
