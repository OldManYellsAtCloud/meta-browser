# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b16e64cc64203bfd45410e2e2d516b41"
SRC_URI[sha256sum] = "8a413f89e4d8fcd733552748ab654da3b7fa4a1395da612159f1b54a40d6a86b"
