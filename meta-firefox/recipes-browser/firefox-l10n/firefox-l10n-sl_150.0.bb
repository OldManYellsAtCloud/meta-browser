# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6d150f947272ea2157500de130e6eb1e732344fe6e63aa354c73ab51d13be721"
