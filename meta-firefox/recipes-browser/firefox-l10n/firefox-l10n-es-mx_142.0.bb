# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64d4b399c72efcdb965c849bc1301ce7"
SRC_URI[sha256sum] = "55eb03154d2c446900e8d6f1a5a72ad5c0aff778dcb61c73ca03c84618638c6d"
