# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8eacfa3e4d7ea5c05b9e39feda97a165"
SRC_URI[sha256sum] = "1cf2d9a9581a426a045f717db81b5308b0bbda11c8aa2e71c70d213fefcd25de"
