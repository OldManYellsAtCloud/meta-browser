# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d5c7041014fa749b0d24270b5c3a7148688d0f31c98fc8bf60a04064aac79012"
