# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "094dcbbd133eef841516bc6ac83cc60f"
SRC_URI[sha256sum] = "0b3614cc693d7c744f6eb4e430de92078b7394dfd5938bdb9c63bf6f72bceaa2"
