# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6017803f09b9ff02b1c08b94cb8a92be"
SRC_URI[sha256sum] = "2c94aefe78c60eab99467f60172f629ec28ef2b62d8feb2c611c88ef68db3758"
