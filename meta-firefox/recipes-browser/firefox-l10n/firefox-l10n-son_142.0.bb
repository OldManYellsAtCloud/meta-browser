# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45b082fc439fe68fe3237de16af477a0"
SRC_URI[sha256sum] = "f23b169ef7eada9e49d6a9120c38c3d46e6b22493aeaf6199f0873214bbb98bf"
