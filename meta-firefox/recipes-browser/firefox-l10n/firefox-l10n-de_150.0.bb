# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a4f3ac4672636f0f3b7ef32c3cd76b702e22a787180b252590e3a28885095ff9"
