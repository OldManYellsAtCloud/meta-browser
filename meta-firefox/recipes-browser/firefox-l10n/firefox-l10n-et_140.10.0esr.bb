# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0671ddc0c5a1a0e9b19e26ee34f92c73f956e0fe79ae9decf246c3d6672cdce2"
