# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eea4077f0edeead1796e4d29af80118c"
SRC_URI[sha256sum] = "5dea6f17ee5f93695fc71440fa5368b631948928fccab68d8ef207b196cf2fc5"
