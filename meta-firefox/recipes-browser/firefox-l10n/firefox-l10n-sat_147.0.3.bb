# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6c8ab5cc16d5773ef7b304e5aada642"
SRC_URI[sha256sum] = "8bd5a6726c897f150a838cbbe95ce08cefa2636a83fc3a5a55e7f2ad20468ef9"
