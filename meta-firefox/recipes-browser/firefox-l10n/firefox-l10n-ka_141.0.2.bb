# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2d42bd8c04fd081e67e9f613a23b636"
SRC_URI[sha256sum] = "1f3d01a0702a1438d5b7e5fbe95061b7fc089aca963224eb2dd17d822ce8d77d"
