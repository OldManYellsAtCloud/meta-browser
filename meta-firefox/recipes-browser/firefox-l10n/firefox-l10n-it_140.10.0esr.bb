# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6e24c7468f1c3386e07c3e9bff9bb3c5fc0816b273d2fea07c9734dc670c2edf"
