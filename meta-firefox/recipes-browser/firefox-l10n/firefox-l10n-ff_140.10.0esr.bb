# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2b258529bb31f1515c2c2e03c7acfe3804978e52f49180aca4be9390a1adc4d4"
