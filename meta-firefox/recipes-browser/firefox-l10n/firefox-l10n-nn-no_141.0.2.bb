# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1832e05c24d6d99b3e3947a001e66d7d"
SRC_URI[sha256sum] = "00fcc7d15bedcce45d0ebd12130a0972a42a26bfb98cbe9aaf669f63c31ed0e2"
