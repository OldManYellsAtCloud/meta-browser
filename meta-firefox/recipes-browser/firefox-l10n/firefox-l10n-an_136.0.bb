# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "390c0d028e79cc0caf866407d1bd518c"
SRC_URI[sha256sum] = "c1fd70c7b550bec5280f8b218d22ad331facf6a3b5f78de64bc5d28048ddbf78"
