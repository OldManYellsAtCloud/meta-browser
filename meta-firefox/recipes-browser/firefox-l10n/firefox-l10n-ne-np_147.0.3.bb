# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21d6d6c4cc95ea1a50879530f8e47983"
SRC_URI[sha256sum] = "9059cb05aee6a343c30b673b741c492e4c277d5e078da72aa7337271e26ab520"
