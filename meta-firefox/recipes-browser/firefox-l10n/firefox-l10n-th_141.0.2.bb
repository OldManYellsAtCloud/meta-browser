# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0f84b7714c29685b47ff76975fc5551"
SRC_URI[sha256sum] = "2d76ae973fc920d53d56b7615f4da7eb7dced146e454f75463b784c059f03ce2"
