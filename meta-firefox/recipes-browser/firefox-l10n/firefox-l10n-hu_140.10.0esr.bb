# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a7d29429a239148b077c597155d97e5cbd53132dab904b465ff2a6e782290cdd"
