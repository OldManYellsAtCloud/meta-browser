# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e183e74a372e0c97afd8913d508d03e"
SRC_URI[sha256sum] = "ce9e2524f31ae8c49f66e9d990c1031cea59d12b6b2c456ddba12d5c3cffe534"
