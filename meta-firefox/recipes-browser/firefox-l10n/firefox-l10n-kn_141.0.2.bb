# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a0b7fa41015d363467210302f7aba84"
SRC_URI[sha256sum] = "eacc5487728496e6b09a0d077140262a715a6f938346a344f324c4e5eb3fb90a"
