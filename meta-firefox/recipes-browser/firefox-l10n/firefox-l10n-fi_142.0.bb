# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af1d064985888e6d72558d412586b083"
SRC_URI[sha256sum] = "7daa1ee09c4ef978ab0be8442a2017b884a4ef9db95989cc836a1a7660066a2e"
