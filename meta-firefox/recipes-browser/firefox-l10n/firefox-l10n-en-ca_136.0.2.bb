# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3aef1db44a1b11ec7abb9d57f709694"
SRC_URI[sha256sum] = "98feaf6c8ee2f263f2d38ce0eefe69a68de8b902c681484826ac160668d2404c"
