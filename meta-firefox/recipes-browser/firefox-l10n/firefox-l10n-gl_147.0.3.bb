# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f7b420ee174b9044eaa15a8a12cdf21"
SRC_URI[sha256sum] = "e73e1f3e973dd2370ea9954e961a4fcf2b51b25613b54a27ba6676d5f775c1f2"
