# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdf2dc50a9d0b4f88f1862208737accc"
SRC_URI[sha256sum] = "f4fc1e9edab3ec3911a95deb1a782d5e2354df569d41f015a76ecbba95a7b5d8"
