# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2031afbfb47d898ba3526ad3868aeea9"
SRC_URI[sha256sum] = "38f3407a0dac50ba43578ecdabf8fd1ad9f9b2878a83a84e924e86875b08fd0b"
