# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d774e6a470c39ef8561a1646f071f017"
SRC_URI[sha256sum] = "ec38f143dccbaed341edad30fe745496c3825055411436efe5f94b9845f5bda9"
