# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d21baa56e4dfc6e0d9ab367242178a46"
SRC_URI[sha256sum] = "f8088c6a0ae73f1c09b5b3198172a9c4841e081abf441c9cdb304f1c8ffa059f"
