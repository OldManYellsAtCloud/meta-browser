# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "359293820728fc7066dfbf1b94ebfdf5"
SRC_URI[sha256sum] = "f6c86defb6421f2f409a39a8b235a82e9131b51d7aa1b39280c0fc2034b340c0"
