# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6b0fa526e3bc55ae545d424a727d9de359761774f12f46c56a3e0fd85e2bc2c7"
