# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a2f78a1c0087b31a98711b5d9a607f2b320e468654ace6d40f58907539c9071d"
