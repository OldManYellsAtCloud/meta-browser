# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e97569116ef913f5bc7272e995daebba"
SRC_URI[sha256sum] = "b9f7f336502d559b1f0ce0807972015dbd3442bba1a24a281e9b6c3d2fa4bcc7"
