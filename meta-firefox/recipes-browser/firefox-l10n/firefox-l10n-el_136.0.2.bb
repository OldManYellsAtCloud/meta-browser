# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d75420ececaa7b136305ee99dbb584d"
SRC_URI[sha256sum] = "728372093b1c0b2cdb9febe3ce6e0c4b69d7ea719655e621f472ca0d9e5bd5b2"
