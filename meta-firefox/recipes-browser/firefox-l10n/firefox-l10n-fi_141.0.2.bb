# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd238be3d97d8256422d31672297ce13"
SRC_URI[sha256sum] = "644b1bdfa425a22f8bfbba887478c15e6eeacf47180ed48237ab7ceb34510d04"
