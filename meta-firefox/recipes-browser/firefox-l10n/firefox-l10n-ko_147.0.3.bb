# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f377197a42ce2c275f7ebfbbbfda80f"
SRC_URI[sha256sum] = "c4594b5442e65d42414d3a69e12b38e4533677a4dae28860ca4a5cb0140e1e89"
