# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7d225d58eda5fedbfd2e06ee5697709"
SRC_URI[sha256sum] = "3cebe729603d2fef3d061c577ef3b5b2fb1ff64e50f8a27e96cd9475bb1abe1f"
