# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5ba64c84740277ffde8c738b44ca605"
SRC_URI[sha256sum] = "441c10dcf70a687b1697023ff65537e79b6de02fdf319bc78297254baec1a398"
