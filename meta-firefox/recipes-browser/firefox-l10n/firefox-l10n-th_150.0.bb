# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "37ab37688dd417b7ed00324729f3a11ccb871b3da2e0b552b7a803d2d7949083"
