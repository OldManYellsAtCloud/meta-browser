# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "83d28b5b6789cfe6f2caad2f5c241531e86453fc8371baf4f17b741612debf42"
