# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6800f5a8ba46ebf8fb7ef0828349f92"
SRC_URI[sha256sum] = "4ec88ba53ddaf791b4750243257b896d315183b2bc8baac739c54df08ce0aab9"
