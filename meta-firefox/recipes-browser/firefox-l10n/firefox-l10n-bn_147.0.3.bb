# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc7556d3de4837414627fbf39beaa89b"
SRC_URI[sha256sum] = "668d45a4697eaae5dc7b594208fbdc6da048dce97a10feeb4b5a1982a02cd023"
