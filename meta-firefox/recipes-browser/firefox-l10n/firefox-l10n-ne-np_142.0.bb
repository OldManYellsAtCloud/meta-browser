# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3671accbdf0d15b8a54018c35c45668"
SRC_URI[sha256sum] = "26e1f947c096129c5693648a7013baa0a98e11d51e210330bc001cb69a47d413"
