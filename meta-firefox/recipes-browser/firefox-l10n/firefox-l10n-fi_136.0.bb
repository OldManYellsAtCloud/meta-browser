# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3af6148df03f1d6c17fc6980b33fd902"
SRC_URI[sha256sum] = "7b05f7e3212b9ca53d0dd43b4bd7a6c6f31121b3724864bb588be8fc05a26957"
