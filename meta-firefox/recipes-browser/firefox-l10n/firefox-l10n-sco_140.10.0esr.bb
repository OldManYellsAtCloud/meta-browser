# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9dbf318da5affbb2535205424cbb5e33721f2d0f3930bc959ff0933603c029bc"
