# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "040cdf2170a35c50be083008d7ba82c0"
SRC_URI[sha256sum] = "03480f94a317b3f9fe619ff02475e22b2de514d51d5bb5648670c2ebe333bcf6"
