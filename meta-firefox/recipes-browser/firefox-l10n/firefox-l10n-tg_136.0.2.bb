# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d477461f3d6f607d7e10def5a9b246cc"
SRC_URI[sha256sum] = "0501c798ea1096bbefe90f494d49f550695433c97da202d99f75af305d61c316"
