# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c41e640a7c461ef9500c66ba0ac4472a"
SRC_URI[sha256sum] = "a94347c6fe0a3c559d313b01192816edce1efddea03b2ce0bcfd225cfad75f56"
