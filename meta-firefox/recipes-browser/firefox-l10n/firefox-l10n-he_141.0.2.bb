# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "741c2ec6bf45eaa3d2520241f4acac1a"
SRC_URI[sha256sum] = "d5e27bfb1db1a287d7c23ae7a006b6225937e0f1a2c41df534977580d6dbf3db"
