# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9a77686f80dee2eb40493a86c679e08"
SRC_URI[sha256sum] = "449abef5598151dcb41daa363b9e9522d0bfbbd5f4bce10e1ebd8d32b92dcc8e"
