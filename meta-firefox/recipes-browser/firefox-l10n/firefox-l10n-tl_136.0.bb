# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8767b394dc097bc67164573597db353f"
SRC_URI[sha256sum] = "eb598e3614f58c0aa0362fb2c6ee135ced247120374a975b70bdbf8c3dc8f664"
