# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e31411b45f940e18c2b51642c103f1b8"
SRC_URI[sha256sum] = "75bcdc794325f4825cfda14790d6094db787b5039192b3fae05fe9ccbf605d78"
