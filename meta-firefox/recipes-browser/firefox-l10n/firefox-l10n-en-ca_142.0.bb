# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a200a8055258bc2d56097c0847c3c9de"
SRC_URI[sha256sum] = "da245e3a1ccfadbe9c401013a042156915446ce5577dfe6238a485423aa30b44"
