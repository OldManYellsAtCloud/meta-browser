# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3293147cf6172196bd0b981b4dc020f0"
SRC_URI[sha256sum] = "4c40f16124e8fe042d209e943e0bf17049c01a74d7da03aa8c9235e838417de7"
