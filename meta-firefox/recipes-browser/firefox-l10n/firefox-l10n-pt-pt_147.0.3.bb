# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "680f4a56105a6f33e175c37a9750f660"
SRC_URI[sha256sum] = "c21e09ad76b0142ebdd4caa2fa640f84062d90377f3c6163fcb56553c277c34b"
