# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "163818a0ca036eeafbd4be12df7ebcd0"
SRC_URI[sha256sum] = "55a06833a2c158fed033f594aa02094ec11b4926d2951f7bc890a4b61495b028"
