# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ee08ad3552a867d737306ea79881ba1"
SRC_URI[sha256sum] = "419f11eaea70dd648c15547fca31f8906433f97c2c05e1101f6aa62cd3c8d2a6"
