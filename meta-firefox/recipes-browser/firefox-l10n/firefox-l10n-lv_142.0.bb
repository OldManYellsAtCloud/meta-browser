# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77074f49a7aa027ce6ca2ff5157a7e73"
SRC_URI[sha256sum] = "3b52d66cdac430de28d69dfdad72c1381120d540b98fe40afc2c90beb03c4db3"
