# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "448d30e54a261ba9a0c90e1607f2f3ff"
SRC_URI[sha256sum] = "de1c8c5c6de4a5203f51e5053b5e2ae8f1282767fb8d160f2ed2171e7ea7a3b8"
