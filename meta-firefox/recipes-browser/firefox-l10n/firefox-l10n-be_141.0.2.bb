# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2b3a918668271c66f496d64b09961f9"
SRC_URI[sha256sum] = "4447eb3af52af52b66e57f4f8289bc7d46e896851c957284f5c53c15d32a95e4"
