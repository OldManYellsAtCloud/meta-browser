# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f9bbd3c01132d951851dbd2f8ba38d4"
SRC_URI[sha256sum] = "56b8ee6c253abc670aef541c5f2a61b6f8fc086fe5d6e24ce6dd123ac997d11f"
