# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52c04ab9368096b41f3dd97374b05a71"
SRC_URI[sha256sum] = "3db02fd39beebecded8185b087a9f1202c5dea8386c0b8db9cee9f6297fb335a"
