# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e231fc41e5ae2c6990ebaa67deb8da82b4c302b92c1ebd342c22a7469de24fde"
