# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7033efc91c50bbde435a7b15c4fc089627ebd6856c6aa339f9fdf52d90fbac7b"
