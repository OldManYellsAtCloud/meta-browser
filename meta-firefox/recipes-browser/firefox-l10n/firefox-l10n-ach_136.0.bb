# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0f49e4244dabd1276161c715ca72fa9"
SRC_URI[sha256sum] = "5eb23779829d7fbe1e51ba92347ea492904a90e5e2730c3f5c918422f79f52e9"
