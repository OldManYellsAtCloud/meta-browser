# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fdf2323c40b7c383a833e525b7cbb09d9504cc368ee9eb60be47ced96dc1ca1b"
