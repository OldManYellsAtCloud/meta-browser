# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "794f8bc8fd0ac795cfe95b3a42c01416"
SRC_URI[sha256sum] = "46bef29f36c35b1beb1d002d34f4df7aed5bd767b2d281e12900a5d629545029"
