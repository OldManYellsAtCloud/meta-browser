# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c415792bdb3359c6f1b1213e818fb274"
SRC_URI[sha256sum] = "6e3ee5a2d6ff9c16c3c808b614fa65ed5990954abc93640634da20768b0d032f"
