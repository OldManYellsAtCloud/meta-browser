# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d12dfb4d564573fb9781da2ab8260999"
SRC_URI[sha256sum] = "ae1cb1a2dfb68abb0ca28e15488d00a18999d877ec59dc0faaf771cd2eb28940"
