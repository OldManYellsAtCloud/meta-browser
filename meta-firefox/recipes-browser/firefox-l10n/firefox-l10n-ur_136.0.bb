# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad1e06c3addc1b253223c072248dbc90"
SRC_URI[sha256sum] = "6c65b987f7a9a797c996f93a970f6d970088c493d6c68e7bcb11bcd927800b7b"
