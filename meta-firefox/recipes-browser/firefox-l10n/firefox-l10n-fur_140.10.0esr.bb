# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8b635beb6fe9e833e0be3fd1811dd12544a7ff05c53e261122f60718cc105dc5"
