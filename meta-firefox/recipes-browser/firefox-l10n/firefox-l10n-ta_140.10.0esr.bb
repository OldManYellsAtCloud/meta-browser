# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1fc80679541740c989fb0ed2c93ecbf17c2c98ebc07aaa36f9bb8e7ac647a341"
