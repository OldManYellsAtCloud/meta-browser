# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47c01bad09adaff6d78032e2d7cb8cdd"
SRC_URI[sha256sum] = "d986e9e0a27c584581d8a4773b40b5157580c7f03dbe8143dda59a566e4cbe47"
