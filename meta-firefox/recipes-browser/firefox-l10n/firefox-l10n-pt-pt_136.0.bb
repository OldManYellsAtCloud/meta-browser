# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00dfab1c80e74300da3af02e2eb07384"
SRC_URI[sha256sum] = "15521de0498084c43c1617b26650eea3f708d295e0164a41eb4f84e73d4bbe75"
