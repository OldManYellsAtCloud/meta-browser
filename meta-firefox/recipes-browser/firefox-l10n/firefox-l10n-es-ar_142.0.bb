# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4ea6fd6e65a8df403c82c9327596f0c"
SRC_URI[sha256sum] = "25011f8a3c7330a66eb3ca8aaf0be87728d557c2d2127170df67d00833ffd499"
