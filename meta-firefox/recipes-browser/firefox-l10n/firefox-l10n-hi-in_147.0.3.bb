# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10b774f00706ad92f9ab31c0c574086f"
SRC_URI[sha256sum] = "92be867fd91bdfa066ce859163261ce5318bbde324e4d58d02f11029207c537d"
