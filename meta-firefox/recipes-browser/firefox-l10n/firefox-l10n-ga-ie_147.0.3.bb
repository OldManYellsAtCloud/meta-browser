# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "058ff86b8e7529258758f4572a06ad8c"
SRC_URI[sha256sum] = "810642f002d646aa415863d54d3f0caa68d8209b5bf9ef6b468e0c458cefab16"
