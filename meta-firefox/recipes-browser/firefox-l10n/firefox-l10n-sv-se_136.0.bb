# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d43d56d10ff2543bb30b6da3d40039a6"
SRC_URI[sha256sum] = "b37af606e84c69554447626aa667f8d1b7bef174d8e66403e4165329ff658a1d"
