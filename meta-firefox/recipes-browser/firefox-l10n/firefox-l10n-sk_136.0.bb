# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dceb9da0d7f80e6c084bdd74a784dc5"
SRC_URI[sha256sum] = "e758ec36e81d57bf428fb40fd4bfcd8f152cf65dc963d20261c5cc8daeb44ade"
