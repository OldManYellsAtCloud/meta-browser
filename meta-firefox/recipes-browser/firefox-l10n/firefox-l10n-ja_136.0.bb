# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b43e98018996bd2843175e1fd9035eb"
SRC_URI[sha256sum] = "1771bd21d93f48db085f85218d8c5c5fea4e417bc55a51da729379cc9c2617f3"
