# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9ee9a6a0cff14fd4327c4ac6fa1b2cd"
SRC_URI[sha256sum] = "0456a3d84559a7d63181086775d25d965c27dbf21030693d1d893eaf1297229e"
