# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f15ebdd73ec66fee1ac7e99d13d759a8"
SRC_URI[sha256sum] = "0442554c6d9a6b8985751251c52926be8cc6c3d76bb4048d62ccebbeff72d7bc"
