# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d58c47f7096b3a806a3d92d51905e439"
SRC_URI[sha256sum] = "1572c909994a152623062720fe078fd57e279ce3ddb3707ca446601dbe61a558"
