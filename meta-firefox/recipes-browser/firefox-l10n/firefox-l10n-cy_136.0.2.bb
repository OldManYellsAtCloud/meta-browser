# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "261e38ddd6d15fbd2deacb8617383d70"
SRC_URI[sha256sum] = "2415312b3576ddc06b6385f491beb0a3647ceb4596714e3b445b77ec375adf05"
