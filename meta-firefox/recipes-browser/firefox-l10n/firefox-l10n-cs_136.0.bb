# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31326d66218e4821f156920e8c1ba655"
SRC_URI[sha256sum] = "28f1397b05fd328f38a971532eb9c9d9961b0a5419f5f7806905a26f6f8589f0"
