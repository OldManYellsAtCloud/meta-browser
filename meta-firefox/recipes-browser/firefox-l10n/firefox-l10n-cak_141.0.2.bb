# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a21e172143b211e0821ae1f6535b0922"
SRC_URI[sha256sum] = "f8c0fcfa1193472f2626198f65079c72360fcfca8d57d06d6bcc56c33f5d6f12"
