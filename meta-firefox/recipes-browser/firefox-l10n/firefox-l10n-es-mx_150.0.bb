# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9d23651283155e2bb826cdb2241d43cfb58d1dfaf5b367d7f8b4c607ab682e7d"
