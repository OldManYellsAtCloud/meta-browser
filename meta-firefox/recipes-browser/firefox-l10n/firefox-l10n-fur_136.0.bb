# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75806195fdceacd920820707626313bd"
SRC_URI[sha256sum] = "4b826eea0dc9d0cd5fe2e525084c603085e2ceffc916ac7b1c9b622bc81a005e"
