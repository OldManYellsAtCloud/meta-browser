# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb7712acc43a4485234a69095ea3ff92"
SRC_URI[sha256sum] = "3501836372ccd09a77c1955238602f8add129336c64f83f1081baaa30db3d8dc"
