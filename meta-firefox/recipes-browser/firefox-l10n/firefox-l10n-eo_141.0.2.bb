# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72c3e2ac89544c3eb98b407713ff111a"
SRC_URI[sha256sum] = "c9916c542bd17446b9ce28a6b8d920678455ee720e26bed0a1967a71af3e95ba"
