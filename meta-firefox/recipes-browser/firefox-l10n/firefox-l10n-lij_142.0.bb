# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13d6fd03c3e3af88ae951434ee5ed33f"
SRC_URI[sha256sum] = "460ca6a0a6803c787d82b4f1309d4c96a5206caf82bb53880d551d920ef3c5a1"
