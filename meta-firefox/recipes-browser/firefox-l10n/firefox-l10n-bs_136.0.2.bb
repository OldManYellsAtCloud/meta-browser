# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e983a78a2c8b002e991c338efc8f297b"
SRC_URI[sha256sum] = "e51347c4af23d13551aa1896c534afb642b8b2153318125b4ffbde7bb55868c3"
