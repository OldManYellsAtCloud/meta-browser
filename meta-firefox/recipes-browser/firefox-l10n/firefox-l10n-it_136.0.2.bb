# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5641bc9c28dccb87a49be8b1581c55c5"
SRC_URI[sha256sum] = "4524020e91f29aeb2bc2b86b3a7e04c2abed5c53b0016f80fdd8610f97a8ed6c"
