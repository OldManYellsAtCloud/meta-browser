# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b951659e9f0fa7b05e97fd056430f3c4"
SRC_URI[sha256sum] = "569c0112482d6e22f7bbd70091279cf352295eb990885faa2e26ea41cbe3c46c"
