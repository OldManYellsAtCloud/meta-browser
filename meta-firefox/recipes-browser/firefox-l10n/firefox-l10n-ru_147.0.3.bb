# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26848702df1f58553b7a512744c1582b"
SRC_URI[sha256sum] = "2f132e3d4f267559a96c4ba0afc366d09c485ff2327ba372d870ae4b2d6cf1ff"
