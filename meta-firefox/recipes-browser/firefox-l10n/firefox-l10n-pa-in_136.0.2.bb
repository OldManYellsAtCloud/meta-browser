# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a2f40d198895dc1bffdbb678bf22c57"
SRC_URI[sha256sum] = "3527f94c93dadd1209ab01ad852c2f81e47c6e6159b244e90db6c9a6dea58eba"
