# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a7a3981f0dc307f1d9c4fbefe1ab695"
SRC_URI[sha256sum] = "745fc7af3d2fdb6c278584e21e96b5e6e1761b6d2e07c93922dbf993937abd69"
