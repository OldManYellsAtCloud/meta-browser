# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9087512c47d18cde2ac0fe907e121dc6"
SRC_URI[sha256sum] = "f7c8f79266f83687298dbbce2a770758bd6a1bad7acdc525c3f9f13a64ea638a"
