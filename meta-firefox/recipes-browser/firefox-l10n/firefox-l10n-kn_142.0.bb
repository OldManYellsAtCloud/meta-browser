# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e16d7b8e8e1c52c50353b1b47e471df4"
SRC_URI[sha256sum] = "f7cab71a38a09172a7fc3497341e7d977b875d76c5fbbb0f5605df29ed021fe6"
