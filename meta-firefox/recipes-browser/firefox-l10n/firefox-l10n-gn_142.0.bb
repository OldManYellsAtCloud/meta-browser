# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d5d294c2724beeee298e6786f9f093c"
SRC_URI[sha256sum] = "006012e6265ce737f3a62a049a5230b98a5545dea6d1c46a8ca527f21d59d170"
