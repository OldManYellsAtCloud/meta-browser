# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d976b4a5fea40348ee66878798a18886"
SRC_URI[sha256sum] = "f6a9172a5e0f203938be8efb1c728281d7b8f6ab99f0bdaabfee3bf6b998eece"
