# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "593877e0d31082960cba88d5cc8f23bf"
SRC_URI[sha256sum] = "8eca26062349e8c0cf2836ec428fdd3f8c70a42fd363c551276e7ff829d9ee43"
