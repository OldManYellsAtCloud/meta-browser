# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "843bda1252292b57e68efb23cd208f6d8a2781e56910cc1cc59b6e18f0fc12c2"
