# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa167fe8edd23644e7f9474b464fbd1f"
SRC_URI[sha256sum] = "485a229ad84167cf213462fa29abdaeae4dbebde232d8d0c4b8df4e254631e6a"
