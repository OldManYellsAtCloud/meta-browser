# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43a68c9b47168a7064d4c75d9ce56a34"
SRC_URI[sha256sum] = "fe4ee048b560862c056358587c5c575eae9a2fbe68c09f2bf85bce2e0ab2c627"
