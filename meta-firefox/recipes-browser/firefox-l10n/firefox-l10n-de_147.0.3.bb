# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aead496c13f32ba2e31c352c51ac1489"
SRC_URI[sha256sum] = "aacb72a6f4a022a2f5f5a7bf2120599dbdc173c0a754edec11f8620591f7b87f"
