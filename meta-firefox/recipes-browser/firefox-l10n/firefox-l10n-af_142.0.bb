# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0040b4e44b5ebbb851e3fafc9514f0f3"
SRC_URI[sha256sum] = "5efc89aef50f3bdc883cf842511ece65ccc5e81dab048ff8748aaab19f9dc8ee"
