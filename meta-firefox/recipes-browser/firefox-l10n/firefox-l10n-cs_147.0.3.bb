# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f8d04bf550c04c7ab5ad5069010d75f"
SRC_URI[sha256sum] = "9c1b141275aa5c39c975838f04804ecba8f363a80345b45f15e1760172881eff"
