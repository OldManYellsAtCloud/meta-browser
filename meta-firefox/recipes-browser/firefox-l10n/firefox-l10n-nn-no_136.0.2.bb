# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1505700f9944182940611c3111a7dd51"
SRC_URI[sha256sum] = "879753127a413b51190b5b7aa7c6a71949962aa515e33c3bd8cb4215b5203908"
