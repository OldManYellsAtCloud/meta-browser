# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9124b324b06ed0f36536defbab678998"
SRC_URI[sha256sum] = "fe9cee3d48a377ce06213440b70ea16e65cdb06e928e4297c5cd4a100ac30ac9"
