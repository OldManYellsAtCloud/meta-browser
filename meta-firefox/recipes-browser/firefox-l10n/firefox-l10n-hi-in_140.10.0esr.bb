# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1adec9e353329317d9d35722f7b3da3a8235d266f91cf37fbc6d8163725826ca"
