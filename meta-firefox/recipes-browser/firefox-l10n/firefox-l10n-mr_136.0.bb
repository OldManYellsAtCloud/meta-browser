# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84513870341e1b32789e52b97e537109"
SRC_URI[sha256sum] = "01b21a23c9b8cbe5cc9758c1af56c61e60edde22a16523ec0fe96c90d8efa808"
