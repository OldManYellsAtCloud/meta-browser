# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e70b2b3154d4b65e0673d5798a79bcd9"
SRC_URI[sha256sum] = "99577a5634d5e4e50cb9d25a21de83f2e541e35511b9a2b393b3a78a929084df"
