# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6d21ae327e2569ffff615231a60894e19559b9ea59f8ae2e0b1a491c58a407fe"
