# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "52b473621c8b003251b34b5548d6022016f0d775753ac5248b2bc777d16b823a"
