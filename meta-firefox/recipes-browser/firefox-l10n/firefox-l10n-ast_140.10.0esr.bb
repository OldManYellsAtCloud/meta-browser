# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "de121a5b3fc2fe0420a15d50745056988608e9e8e4df578f0d3a1e72060e114f"
