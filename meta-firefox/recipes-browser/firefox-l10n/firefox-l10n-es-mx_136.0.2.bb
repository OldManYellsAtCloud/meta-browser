# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6eb5c9b5c0d310930c702c7c75ea0e81"
SRC_URI[sha256sum] = "b797d59bf91dc3ede76745d444a3dded02f780b7b1788ad774702fb44caa58ae"
