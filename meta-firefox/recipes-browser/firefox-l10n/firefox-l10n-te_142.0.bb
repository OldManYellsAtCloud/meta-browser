# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d4cca98a63f10bc7399aec1e9cf6c09"
SRC_URI[sha256sum] = "29406b03080bd31c23860933036f97b65f47cc25f4c1a01aeba94ed475c2fcd6"
