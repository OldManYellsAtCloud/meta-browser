# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "523fc5ca7f60e1e5db139113588da00d0120623c278e3128cdbdce201886c8da"
