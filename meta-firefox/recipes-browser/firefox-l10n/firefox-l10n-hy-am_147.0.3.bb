# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "845c023070203b272784a4cc038127ce"
SRC_URI[sha256sum] = "6738e14d404ea090ee8865f9ea7e40b21a07368d7ff7eb30fea45a727c51e74c"
