# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "667253b845bd3ca3b9200fa115209030"
SRC_URI[sha256sum] = "36196bff75336c9eae0d3f69223f5ad755a9a6638e7debd6a5198aee2140a12d"
