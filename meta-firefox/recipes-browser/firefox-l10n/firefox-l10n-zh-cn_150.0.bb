# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "999052a7c63f5c584878252470894a44dbf2c3a49cf94e05e38db7e1909e2e84"
