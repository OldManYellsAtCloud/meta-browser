# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a0e4fa61e2d50a52f384d0f54da95fa"
SRC_URI[sha256sum] = "6404544e2db765dbc74c3d113a8555316344a6bb9167757eae8e7e8ce1c43e35"
