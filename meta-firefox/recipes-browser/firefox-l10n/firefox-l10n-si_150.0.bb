# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fa778ffd83ab3a6823b7b5f8dadde4602af85bb1f6353586ac7062d97a904a3d"
