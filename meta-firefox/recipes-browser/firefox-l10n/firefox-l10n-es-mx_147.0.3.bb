# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7227295405e367c3bc1ce6f57ac86fb"
SRC_URI[sha256sum] = "b2575aa91e79c8ecdbbf1427b4de3b44bcd758bb0b494aebc55240bd45fdae28"
