# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbbcf547298fc0155431a02a3612f5a1"
SRC_URI[sha256sum] = "b42913b1f32708ccd0861132bf4f98aa1402a1aace748ef5018e3d83e8c19c46"
