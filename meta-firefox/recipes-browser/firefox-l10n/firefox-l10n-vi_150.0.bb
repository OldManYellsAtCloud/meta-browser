# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "66097eb4a50824a9ddc249fa1ff8263c5dd0859540352875d714e47d56126aa1"
