# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39994326ef6c544fbf3b86b62361c7e5"
SRC_URI[sha256sum] = "a594ebb411dcd12c7471965e7cdcb98799c723b07985c36b85b4adbdb6763d0a"
