# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e66769d76941516840516a0cb6fc9fa"
SRC_URI[sha256sum] = "b957baccfda80c6d18321b730445fb69a68350caca46012e48db3883df1d0768"
