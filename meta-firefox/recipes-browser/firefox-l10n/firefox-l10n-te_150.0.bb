# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bf530cf5ff17b23c46f76d69c095daf64bc0d5c029a4ce601cd4fada770a937a"
