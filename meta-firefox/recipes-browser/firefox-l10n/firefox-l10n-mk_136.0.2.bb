# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "387c008d1740b9ae1fdca96df765b9c9"
SRC_URI[sha256sum] = "94888bce5bdc74de068751f388e856af0ba7a5901c746052d0a1f6253cdfb0d6"
