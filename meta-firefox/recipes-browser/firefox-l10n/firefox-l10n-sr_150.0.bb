# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5b1723b79bd8861f63f1b62782c4789f6d805983844a56e4777540d039cdf836"
