# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "353713b2991376c18b5909d641cf9f28"
SRC_URI[sha256sum] = "a49bd8c84725419fc9331b8fb4d3cd43a6ba331503c55eb963eabe8621aee506"
