# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8e5c418947113e2eabad0234db4dc7d"
SRC_URI[sha256sum] = "6e1d76efc322b4eae25155aaf55f7b59b971283d134f2a7c9ce973d5d754db94"
