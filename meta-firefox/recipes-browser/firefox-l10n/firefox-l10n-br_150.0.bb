# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "02aaf6b6f505335c4845c94d944491bd4331c1faf447d24a032ede9898923d8e"
