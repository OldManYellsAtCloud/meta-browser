# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6fddc8296edb742ec1ad990f04ff2b4"
SRC_URI[sha256sum] = "a654c833eebf7ba3bbe2dfebbd334de97004a7692e2ce36592ce52e0ce7f79f0"
