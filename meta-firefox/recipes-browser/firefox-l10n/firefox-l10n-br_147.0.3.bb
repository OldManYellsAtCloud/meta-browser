# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a07c783f3d74a8ba5689f0735ce02039"
SRC_URI[sha256sum] = "1605bc93fa5f4f5a480f97a494e9e76d4af65e56aa0fcfc4357131280d353004"
