# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a14e65f23b340b633fc1f3441779ecb9"
SRC_URI[sha256sum] = "64e45549e92bde5c954bb73bb57327e8e0d7ec41e63559be7ab906aace407160"
