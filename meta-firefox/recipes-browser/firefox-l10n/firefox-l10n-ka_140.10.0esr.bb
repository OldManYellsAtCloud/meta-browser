# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f965bc6c8cf75bc47a2b3790c3578e465dab0a516084040631f4bb98eb76cf86"
