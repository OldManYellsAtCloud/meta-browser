# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4f2bf62ad367ce372300b07e51b3386"
SRC_URI[sha256sum] = "7d463f1cc55f17475f00de53a2fa153f577bda160a8f3f27886a829e64992152"
