# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "05bf69ebc2b25ff068ebf2e552fda680694ea67573bbf3c66cef3279d7998cc2"
