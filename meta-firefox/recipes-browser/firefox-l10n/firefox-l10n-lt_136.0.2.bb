# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36f99941ef8f36dac0650dfb57e9e9fc"
SRC_URI[sha256sum] = "c630a7b21afbf1672275ad17d4db46820df01491ebde1a9e265172af9adad8a7"
