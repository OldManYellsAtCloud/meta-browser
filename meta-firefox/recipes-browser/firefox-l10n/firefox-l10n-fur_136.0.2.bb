# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc284cec7ac5db0a183b8018c2186a92"
SRC_URI[sha256sum] = "dab78bd55f54a261772a6ec859574056a015359dc6a4b1af71cda8cf43f46fed"
