# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "116b12ece56ee85bec10620c10c08f39229251611039fb39d2b8686f5fb16084"
