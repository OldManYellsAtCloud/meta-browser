# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "721115e6f3ea0c4cfac583d7aa06a6f8"
SRC_URI[sha256sum] = "0aa76b582898e9590bc10ed699be4c8b04ff8de4589ed93de2cb4690f0e9fba8"
