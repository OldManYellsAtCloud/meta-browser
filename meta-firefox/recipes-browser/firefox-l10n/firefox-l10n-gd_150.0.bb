# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e6885b14286ad6532d2e0822ae863a2f3a49e651aabec0125ec552a7befe87b0"
