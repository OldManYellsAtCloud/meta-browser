# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de77a00f8911ebf189fe2b07858db62a"
SRC_URI[sha256sum] = "687e712181f3b8c7f1c6491c15ab66c819c520974b6bed9190804b65efec4da6"
