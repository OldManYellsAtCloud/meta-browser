# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b5fe3f5be8d4fc7d4016462c914e206"
SRC_URI[sha256sum] = "004642adff8a8ca985d8d484c3eb7682d37142cedee1cef06e8163ea18f01604"
