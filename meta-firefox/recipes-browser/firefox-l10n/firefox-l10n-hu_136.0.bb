# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c874dc87c852ceb9f79d0ee533cbcb4"
SRC_URI[sha256sum] = "4290a28abde3f32443066314c6cad5ecd05280017513f8fa8a041a2549237b1d"
