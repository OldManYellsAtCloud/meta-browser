# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "222103b9689dea8ef1effae72dbeed4c"
SRC_URI[sha256sum] = "ea87320fda70ccb22d6293ee16b4fca51e20d4eaea923d82a0c9b7891769a233"
