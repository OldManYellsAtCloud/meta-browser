# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d1304c1825bf45dddda041d99d4dd9acaf0b47459f7d73b720bf33293f5bdbc1"
