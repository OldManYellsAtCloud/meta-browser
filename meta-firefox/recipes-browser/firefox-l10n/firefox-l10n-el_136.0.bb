# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7224e4269bc4b3aeef0fbe17e76d6d7"
SRC_URI[sha256sum] = "d182afe05202e2889b4e4c365386c68cda4b81b9adca329fe08a4ec4bcc35e47"
