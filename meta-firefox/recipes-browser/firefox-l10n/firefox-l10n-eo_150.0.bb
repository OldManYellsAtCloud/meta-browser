# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "356518a683e56b3c06dab03b3cc800aa41daba33fa993340df1943e3c56bb55a"
