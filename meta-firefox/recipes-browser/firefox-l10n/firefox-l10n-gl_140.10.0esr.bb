# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6f13ed73bcbfead1ae50152f5d63afbae337185c67cdff156ef9ad21458a6e1e"
