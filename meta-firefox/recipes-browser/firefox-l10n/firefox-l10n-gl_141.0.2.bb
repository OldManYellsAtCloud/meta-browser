# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "392fe9ae125f9e1d67e0ce2ffc15a42d"
SRC_URI[sha256sum] = "4e28634f7714da71ea74f5f38641af440e2f86dfe5dfcdbabbb2faa91fcfef46"
