# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e1fcbe278e2aae124fba3b16d1571c9023e4dde52300d7aec27b9e589289095d"
