# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e6a38ae30e4418bc80c186ad789be4245fc72fb3546eb919911062d669b5685e"
