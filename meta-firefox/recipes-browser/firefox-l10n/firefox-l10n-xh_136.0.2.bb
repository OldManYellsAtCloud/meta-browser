# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe04da4fed29462e8c55ef3a62e77b85"
SRC_URI[sha256sum] = "51cb1d7420ca97826baa94d9b2b9e71064f35a47e29e4f9c6b2a82ffdca6e579"
