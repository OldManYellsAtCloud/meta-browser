# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "414a76bf40d5c5f77cd5290ce99bc68c"
SRC_URI[sha256sum] = "80140f754c39a9abafe03142d793433882b0aad930bc63f0d056ed4b816c870d"
