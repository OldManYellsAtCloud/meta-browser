# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d72a9bce0c6290998c9c20d680985085"
SRC_URI[sha256sum] = "3d8f21d1a675b66f939bafe0f8e382794dae617d7fc49237d1c099c2821448b7"
