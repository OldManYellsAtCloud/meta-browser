# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "275cfa073dfd46c969ab92706c86e214"
SRC_URI[sha256sum] = "688058b33a5cab6d6d7a37248dcf13d23f2ac19a7ae76cc3aad79e6ea2666ef3"
