# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e6da454e80cb23d44a050dec51b5f61"
SRC_URI[sha256sum] = "5529944ab15898a94f99502ab377b8269023591ba8996b930f1def7976ded25d"
