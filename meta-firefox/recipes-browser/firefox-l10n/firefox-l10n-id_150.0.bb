# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9125b59d060248a6694f24b5734fb4bff17745057b82ed45d88d5601704ea9bd"
