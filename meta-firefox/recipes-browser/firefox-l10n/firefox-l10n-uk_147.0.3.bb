# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "352217c4d42b1a815d15832561487a3a"
SRC_URI[sha256sum] = "74ebc26f47ccb6c1a821e683a62c4061269dc3d357e3449f0743823e85192da6"
