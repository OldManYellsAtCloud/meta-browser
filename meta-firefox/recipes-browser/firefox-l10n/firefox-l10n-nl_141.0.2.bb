# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47873f3b26e4be31c4668b62c81c2fc0"
SRC_URI[sha256sum] = "bf661bd633d9d4a4f9b5145f754dc27f304c700632ca796b98c04f1e4bf3a0fe"
