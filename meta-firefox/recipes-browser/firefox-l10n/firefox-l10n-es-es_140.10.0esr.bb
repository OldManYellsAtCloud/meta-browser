# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d7f15744916607cf518e6343ae57774dce43cc8f1c5db081b3651e436881d969"
