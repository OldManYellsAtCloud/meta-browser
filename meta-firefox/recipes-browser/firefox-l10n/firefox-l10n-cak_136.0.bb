# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75198fbd2ea582eeb0f7b85f2d906978"
SRC_URI[sha256sum] = "36d0cd4f4913d39bf782eba3c71d437695a2ae09f136e300b94ec5a3bfd7fb64"
