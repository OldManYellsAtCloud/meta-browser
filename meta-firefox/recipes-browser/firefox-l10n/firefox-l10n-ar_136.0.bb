# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6198c09bdbac0bee708a8f249a46c54e"
SRC_URI[sha256sum] = "a157fe1aa8cec0dc25ba4407dff05a0957f55aef0d058ae721022a4f34922ec2"
