# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "687c4f85fad356c817b1a7e2e4a36bd2"
SRC_URI[sha256sum] = "8b22fe71a52da3197d75ddb947d6a582472df1c6e72e7877bafba77431470f10"
