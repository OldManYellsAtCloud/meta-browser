# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a6716c1cbd0721bc6362928d6357a87"
SRC_URI[sha256sum] = "23a50c481121b883fedfa64dd3db0440fb52053f9066972ae200979986c1ca97"
