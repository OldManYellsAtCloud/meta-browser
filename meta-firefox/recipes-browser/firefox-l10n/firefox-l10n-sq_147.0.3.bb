# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39cbf74659b8f5c0057dc4d6f33e5004"
SRC_URI[sha256sum] = "15638830e1dfe4038a474f1cbb318246f3b4dd501f8a74bb8e86044c060a3024"
