# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4738de8f427ab7e91b10904df8d90ff8"
SRC_URI[sha256sum] = "0ba4bf5c1b7f99c729cbdba258e215c2c0bac3c4af35ed28d703b284b35aa35a"
