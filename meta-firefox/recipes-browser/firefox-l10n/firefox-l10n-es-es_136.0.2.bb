# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7bcc55af008fc9af2d0d021584d4693"
SRC_URI[sha256sum] = "dc9a2bb9dd4a42cb40a0532c01e5593dccd782758fcac34ab22a4a5e39c61bee"
