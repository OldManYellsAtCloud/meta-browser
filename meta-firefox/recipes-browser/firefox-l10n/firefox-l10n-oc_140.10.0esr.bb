# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2557d35a3089e3de3f757be5cffae4db922ef0c8f45b77c6eb3f222a2bfd9fdc"
