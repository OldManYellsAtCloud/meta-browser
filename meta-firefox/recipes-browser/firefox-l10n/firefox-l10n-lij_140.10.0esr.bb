# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "35b9dca6bcf35a1cd9632acf7a1374ded2e487d3c5eff8b414ae3eaa836352c3"
