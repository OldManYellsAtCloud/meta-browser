# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78ca3fca2b182f3f0accb40243d8dc2d"
SRC_URI[sha256sum] = "6d2418912b37632e74d282f34b47b4c2d003d626f49a6ed0330e7d96d9ea4a22"
