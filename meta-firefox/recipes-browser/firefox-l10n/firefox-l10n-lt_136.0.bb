# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2be022ca6a7f39a2a48daa07d0b5d96b"
SRC_URI[sha256sum] = "dc74d689f347c0310bd5e749bf5ce4a67f751e856ff7af5d337e03ac2078445f"
