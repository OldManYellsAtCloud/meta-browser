# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2eb7bc49fbbd7fabff47ca3825b9a8a8"
SRC_URI[sha256sum] = "98cadf8f69d0ec06046cb6270266ce6d8bf50e27578364f3308568b7a08ffaea"
