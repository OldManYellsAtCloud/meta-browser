# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2e9d0fb1f9a4696c8c0538940aa04d7"
SRC_URI[sha256sum] = "1784fade97563494ea5a413d25fe9493a0ef52bb52c9cdf8cc1665bcadb11cf0"
