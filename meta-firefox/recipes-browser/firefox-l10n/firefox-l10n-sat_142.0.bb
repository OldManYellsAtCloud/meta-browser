# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96c65b0104af36d44119744345b532eb"
SRC_URI[sha256sum] = "040721c42b07aacd1caa5e803db729538243037d0129d6e90f9dd9d7165a813a"
