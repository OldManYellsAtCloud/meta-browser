# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6b6deb0ee1ff1ad52e03c774a7803510093047bca147e5ebeb8c22664dc7381f"
