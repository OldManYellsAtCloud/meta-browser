# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "47c62fd4644a7f0ae64c4184c8af13a2a8d1a2acd30027e6ef1e0e53ada079f9"
