# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a0b5a7197d6bbbf23b7c005634a8d34ad27c5c463646e1d3c647f222318150aa"
