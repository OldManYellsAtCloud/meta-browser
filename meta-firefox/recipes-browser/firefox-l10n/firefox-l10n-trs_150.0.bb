# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "01219f5ab0bb4739c4df0cedb297091df4493cb0d0649f52bc8e9bbc0beb361e"
