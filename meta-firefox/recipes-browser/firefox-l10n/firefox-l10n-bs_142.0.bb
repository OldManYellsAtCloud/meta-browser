# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2ec9b2a8adc08e83073ebbbfd62f62d"
SRC_URI[sha256sum] = "a36839b5a00ca22886042ef7f3beaf059d681ce701099b540175499431aa666d"
