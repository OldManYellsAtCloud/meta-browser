# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b7937c6400e4b1c199adb3e96f4eda"
SRC_URI[sha256sum] = "1e7b1f5506c4580f5f3cfcff9970b85f293784bfbf67db7eb7141c239c7e0276"
