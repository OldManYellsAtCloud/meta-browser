# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adb11ae647d4615cadeb0164190788ee"
SRC_URI[sha256sum] = "3a4118e975c5e24ba1fbb7a65c71938ae1987c6ce70563c45d717e31ba4131ee"
