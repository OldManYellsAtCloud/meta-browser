# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42ea178c85fbd159b7c3ffa843c7a029"
SRC_URI[sha256sum] = "4c1507bb9bf454eb3b84b90480dd522bbf3ef486937596081f41a0565a173c7f"
