# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "318b57479cde146e3e85b40b94273858"
SRC_URI[sha256sum] = "6b3dda4f88874fb8186a18ce8f77a034661aedce5c0be910d30ce019204f3a41"
