# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "453648468736a2d18c5b59333d968830"
SRC_URI[sha256sum] = "f3c22fe4e2072275b32a318b20fdba7af5ed2c27a9350b8119e347f677ddc409"
