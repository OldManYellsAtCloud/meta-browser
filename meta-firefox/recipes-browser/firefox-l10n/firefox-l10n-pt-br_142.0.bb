# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "133771104c1056ce34c830e83756f168"
SRC_URI[sha256sum] = "3cf4eec6f3117eccc127898a22afb2fd235ebc8841f8c91645afccf0c0dfd1c8"
