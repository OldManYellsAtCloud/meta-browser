# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab6d7230e29fa9bbe73562f0ae48357a"
SRC_URI[sha256sum] = "a05b6fbb78a285881ef1143c8bb897d929c1a9751eb7cc3d5fed862dcc71734d"
