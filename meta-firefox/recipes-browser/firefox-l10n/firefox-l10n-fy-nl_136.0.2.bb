# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0286dac245ad1dfd7ad219ba99683871"
SRC_URI[sha256sum] = "19068c93189dc340dcad197d7dfb3040d8647b31521905e27ae2ea0413d7ca2c"
