# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79b0a3a9b1c91ca80775c6e183db6d69"
SRC_URI[sha256sum] = "1a1819e062c2813388595c4d526a7182767fd9e7f78a5fca1c68bb08bcf10dc2"
