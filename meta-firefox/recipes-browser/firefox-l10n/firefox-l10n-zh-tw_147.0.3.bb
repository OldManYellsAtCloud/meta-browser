# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c793007d15a5bdbfa1c6b3a7cacceec8"
SRC_URI[sha256sum] = "14d6d1774a3a3fc4c7cf622dddc7bf0c66ff135b4890f01864c255eea914debf"
