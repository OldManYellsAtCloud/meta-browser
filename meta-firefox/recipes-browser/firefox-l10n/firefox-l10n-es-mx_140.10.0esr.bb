# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "318c870a6c34fa733362b331956cc6904b97995dc95bc08a773f6d5c5628d45d"
