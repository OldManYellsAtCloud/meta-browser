# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efa66f7d62f1fdbca902a78888b82017"
SRC_URI[sha256sum] = "711c0082ebe65a57290c52ec09ca075d595f84f46aed7c61a5124e7fe473db59"
