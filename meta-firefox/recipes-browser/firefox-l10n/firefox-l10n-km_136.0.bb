# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "770d8fe0b719593b8d91e6f7430180a1"
SRC_URI[sha256sum] = "d84271127ed1affe72c12d94d87f120aa0c848442b4fb5dd7469b7069182c078"
