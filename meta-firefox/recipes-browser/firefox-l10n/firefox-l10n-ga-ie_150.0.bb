# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e2c77b701e7fdb184808a8dda353e1879543a7f732f785b1126ca442a31e8a1f"
