# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf5b13f6bf09b06b060a4121d01c1ff8"
SRC_URI[sha256sum] = "da2d005398004e862c276f1c684c9d97c5d76ee88e800bcb9278dea34372891a"
