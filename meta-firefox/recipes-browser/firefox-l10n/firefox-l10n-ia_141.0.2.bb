# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59ec6c2b24b0a4b6ec321d5b0a9675c1"
SRC_URI[sha256sum] = "7e9ed628386ad716dec5b784d64e9aba60d15205f133caaf44dca8ffd91dac4b"
