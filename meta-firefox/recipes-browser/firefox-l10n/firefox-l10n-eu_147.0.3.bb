# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c02babde896a92bdc54e2d2fe2788486"
SRC_URI[sha256sum] = "308b7cda8afb9e9f01c6fce4dbadc83e61b90b1d20258463bdd548b7f4a6fb1c"
