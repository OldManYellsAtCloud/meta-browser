# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fa395d3c40bc7d0975a3925cb55a19c"
SRC_URI[sha256sum] = "8129c591ffc1de4b4e1f6c099b91e5c5dfb6ccb01bff6c66f04615ac30b352be"
