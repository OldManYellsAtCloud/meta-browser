# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd4f09f8fe139f063bad25ec638a62b3"
SRC_URI[sha256sum] = "d3800f969fa1ed3b041d0350abb00d7608bbd4930730492c368b700803ee18da"
