# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aabfb55bf5c790165725095f53622442"
SRC_URI[sha256sum] = "419e830229bfd31a9402a41eb5b0d85ae1c5c5e96b13f5f2aacac348501f1db2"
