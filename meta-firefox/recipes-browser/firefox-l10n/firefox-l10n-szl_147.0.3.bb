# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30dab70cf394964ae4562e305b1f8a88"
SRC_URI[sha256sum] = "83455cc247839d0bdc59490584c265d207cdcbd1372fc4c03615c13d15e74e52"
