# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "487600e8a77d22fae30c5e52ff5021f1"
SRC_URI[sha256sum] = "4dbba01dc11b343df0aa07106d4d8079664858ed567898fcd79c486e74c3e33a"
