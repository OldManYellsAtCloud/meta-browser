# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf30bc703869285a12b8840d56050f05"
SRC_URI[sha256sum] = "475f63e7acbbe411c3901f5a432d7631ee8cd65925a49a3c1cf119d2a3567104"
