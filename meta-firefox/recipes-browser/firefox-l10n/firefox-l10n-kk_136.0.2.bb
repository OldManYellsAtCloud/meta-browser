# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7df88f39084c9a35da6ee6221e2bd3f6"
SRC_URI[sha256sum] = "b4b38cbb65f6f37b47cb4939fb505de7337e1dd9e2cf6b34beb6ad9ef07db0b0"
