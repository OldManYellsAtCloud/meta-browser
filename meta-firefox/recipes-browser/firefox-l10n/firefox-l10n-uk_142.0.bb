# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e13df97834bdeae50a347e6317181e32"
SRC_URI[sha256sum] = "3768044bacf67d375b0d95633e03d3d46b30c1a68336fbae69549dca47502095"
