# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e2eac8e4fde866fa75a586dfe48d2756b57606ad209af1e07b04406d0b4c8375"
