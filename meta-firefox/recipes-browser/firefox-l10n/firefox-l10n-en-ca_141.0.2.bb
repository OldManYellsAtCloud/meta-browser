# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bfed7704b08b18c5eab583f3db803ee"
SRC_URI[sha256sum] = "0f7d845a653817dc9c4f053dc200fe56305eea93e7a62e64ba502fe5aade946f"
