# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a3ee0e9d08e383c6fb6d1a87cbd8ada"
SRC_URI[sha256sum] = "32061f42c85deafe3da12799b0d1673fecfd9bc0c1e1668a7cf3daed248a031d"
