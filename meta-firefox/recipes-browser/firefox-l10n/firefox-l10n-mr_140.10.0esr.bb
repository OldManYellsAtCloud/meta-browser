# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7fade8d525ff14c3aab7a4c11812c9cb446c727e966f627ede5440b295bdb4e0"
