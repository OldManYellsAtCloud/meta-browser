# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ff81ad71a22556cc17ab3a9712838b72ba3e3d330f10f5a21ed7ddc29994d512"
