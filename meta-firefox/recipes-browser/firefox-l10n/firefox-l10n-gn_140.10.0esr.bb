# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c63c2e9fd9e3e3b4fe2a256346534f69c30af6c744f4cc18e9ddff2d81935d69"
