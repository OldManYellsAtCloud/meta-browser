# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1f80416ed3d0d0723ddbc35c167f4c3d8f61e7fc76d88f26db32af6ce7a7cc3b"
