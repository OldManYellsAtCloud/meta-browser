# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d9f46c5efbf0749ee44ff46f0d7d735"
SRC_URI[sha256sum] = "367fe58b2d3c1635b1cc2f636c0c089b73360588fee37cb8c881f88316142a20"
