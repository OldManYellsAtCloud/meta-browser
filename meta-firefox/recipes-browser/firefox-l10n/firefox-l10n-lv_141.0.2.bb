# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adc10165f0086ab136a231eb02f781aa"
SRC_URI[sha256sum] = "7a3c8ae4befb200ae4dcbcaa3c91dc2fc192420d9f0245c0466dc710135f52d4"
