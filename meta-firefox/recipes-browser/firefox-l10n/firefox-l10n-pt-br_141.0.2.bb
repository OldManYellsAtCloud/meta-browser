# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e3d9ca15db84102b8467ff52d422760"
SRC_URI[sha256sum] = "99eb9522317e9ca3d16a0f9688a0e1277aa94d21ba77acb6a38ac623f5dd0337"
