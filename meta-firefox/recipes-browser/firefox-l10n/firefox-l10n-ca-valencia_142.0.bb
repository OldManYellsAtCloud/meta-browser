# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb2f89fc7add96f524d25e4d7dfcade3"
SRC_URI[sha256sum] = "c21338ff998168ab20f58f8b7cea755054dbedd65b6b38596f55e0ec1f00d1c5"
