# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57b1ee2549256e8fe24e8978c7c6e86b"
SRC_URI[sha256sum] = "c8c74bbb8afd5fa0df09ff2dffcaa2de5f16251b6a9f3de300165aab1ea131cc"
