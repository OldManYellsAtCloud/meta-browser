# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7663bdf375fb9d42f99bbe2db18f1a007618a722275a8dacdb1a4ff8a4f3f62a"
