# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc5d7468294db72de468f210f64235e"
SRC_URI[sha256sum] = "92f2980f3d5dea599f104488758b23912cada07bb8f97711e92fdb735527f52c"
