# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6d0fd01a6819a5ad00e35ad35ee4c04"
SRC_URI[sha256sum] = "229840eb64687aec33055b63ed910a31ecc33be40741fe8cd04c4cfb005c2f31"
