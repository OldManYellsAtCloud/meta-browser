# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f727e68612b449f7a3ae070654b73ff"
SRC_URI[sha256sum] = "c76f1e74b8aac1db3867318e96e48aec87884f3e6067a3d72ab75a5b3cf26392"
