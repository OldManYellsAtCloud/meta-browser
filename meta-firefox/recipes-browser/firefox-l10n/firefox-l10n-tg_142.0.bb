# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a574e11bfe0fd3a07123cb7ad70f592"
SRC_URI[sha256sum] = "5569acd69907fa23fb973d053da4fc8cd6951e6cb404d7e5652a9b9cfadd5234"
