# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "504c5975a1181819f28860ff86bb1dbc"
SRC_URI[sha256sum] = "35ecff1e766fdcc9c9ec28d0a6d63af4eb6c18364419390501bf7a825cd5b933"
