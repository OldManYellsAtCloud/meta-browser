# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "383bdfb83e93bfe23bac87e88a6b45954a3e68e1dd78b58192c24ee3e7ff8f34"
