# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26fb579fbc0ec6cc80185f2eee96deda"
SRC_URI[sha256sum] = "789a977814125b0f68e5e053271c65b43d1d35aaa7515b8b4bba28127827174b"
