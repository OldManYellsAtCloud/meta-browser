# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0e5a437536fac80f9adef712f2c3d22cd130337e188bf07c776c5c0b50cfee94"
