# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2098fbcb54d87eb73e4905a499558a2c"
SRC_URI[sha256sum] = "4bb5997aeda664eb69f9f23ed9a91265359e78ec6beede54f15dba7d6e59f093"
