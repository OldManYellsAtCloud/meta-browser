# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d73a3c03b0141b22a686920aeca68dc"
SRC_URI[sha256sum] = "1db6a2bb2affabccf3fdf15a055af50c18e2b951cd7101dd00140a8a684f9a37"
