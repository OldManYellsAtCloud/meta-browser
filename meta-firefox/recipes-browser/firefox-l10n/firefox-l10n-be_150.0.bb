# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0bcd926ccccc2fbb4b58615253a69be89537185cdb70cbbe1876393d75512ea6"
