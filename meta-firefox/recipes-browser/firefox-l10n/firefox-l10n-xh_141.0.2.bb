# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2663f4ec098214c475a69da57fcff6a0"
SRC_URI[sha256sum] = "6f7281b7493cd8259f61917b3e838d17ba6f00894d89ce3d68c7ef01c4bab85e"
