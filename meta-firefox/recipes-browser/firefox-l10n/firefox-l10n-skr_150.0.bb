# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "358eba1afdf0a8c45a1ceb133c95d71a13eff9509504fb6ce2334cae716a0af4"
