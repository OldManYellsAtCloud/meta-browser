# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "044468a0a9f5f83656b5f8ba626d216a"
SRC_URI[sha256sum] = "4b964c8c2dbc89ea54bb598e15844352a34181543141967da40bb21bcdb65118"
