# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e638a39b435625946fd9844b54e59e73"
SRC_URI[sha256sum] = "04f44cb0241b675c03609891e976e4b19a3f86a97124c814b9d0b34d537bebdf"
