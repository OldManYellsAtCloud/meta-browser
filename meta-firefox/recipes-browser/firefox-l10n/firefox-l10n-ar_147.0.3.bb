# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f90e87e7d8bbdcd39cc0b035be428c56"
SRC_URI[sha256sum] = "e53878de7fc86e2be050859ce3d977e2a1b7d8795e9e76a0a11652d87e19052c"
