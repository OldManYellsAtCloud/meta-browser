# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "680b6c226e9fc956e167554a6976dff5"
SRC_URI[sha256sum] = "7b1c3c2704113f12c45554353d8436aab77d9d7c13d305a814457c02456862d4"
