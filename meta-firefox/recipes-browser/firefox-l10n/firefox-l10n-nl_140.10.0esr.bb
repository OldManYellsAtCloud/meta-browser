# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cf575842ddd52b1a563711309c6d2b589a596b807c2323e761e2b0dc2574f0c1"
