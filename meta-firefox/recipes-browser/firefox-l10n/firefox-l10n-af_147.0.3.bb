# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39020747bccc434b10e90fb55a695f8f"
SRC_URI[sha256sum] = "c8c68851c0279edc44736c8b872aa6c7fa8b81bcd12946142c397467ddd6a40a"
