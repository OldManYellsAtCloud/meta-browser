# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a5145e43d5e7f64f61ea10c97e57ec1"
SRC_URI[sha256sum] = "4b16b85036f9ea7388dcc1d2e67971e35fa792f054e1450731dd84cb73651af2"
