# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "020c82e33a6816c4264af2cc568b1c80"
SRC_URI[sha256sum] = "c5a4329211f377fd79f7eeb64994a64341c3866a1767d4af0382d594b44e936f"
