# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1714a0bfc866e6e4225117c1b280b09b"
SRC_URI[sha256sum] = "2fef2950af31842524456a483e887b28cf5fe5ac6139604168b36ba1786f961d"
