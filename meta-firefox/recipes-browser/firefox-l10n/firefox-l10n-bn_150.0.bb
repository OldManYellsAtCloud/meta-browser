# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "46bbae0b333a9cb207ca4cd30090b71c6e28fa19b43ee1edc8442ca8b1af4568"
