# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cd72aec45c4b90f41ca512658ddb3b2"
SRC_URI[sha256sum] = "0d0b64f41d8abf512ed44afb74b8b496dda7a775a69084d6ebe5412bf9395b3b"
