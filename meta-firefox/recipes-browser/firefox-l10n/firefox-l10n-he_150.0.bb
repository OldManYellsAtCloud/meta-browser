# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "db9f3cb682018f87e4a32188e65f71c49da23dff77f715f497627fc87686192d"
