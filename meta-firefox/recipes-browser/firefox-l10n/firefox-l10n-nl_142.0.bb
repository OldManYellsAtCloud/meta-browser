# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5842d9a3bcd1e3b862bd6a3adbf5f2ba"
SRC_URI[sha256sum] = "6f0fa941ce25fe6c603a3873b1e89de13cff583ca2f8ba6ff450543f78227732"
