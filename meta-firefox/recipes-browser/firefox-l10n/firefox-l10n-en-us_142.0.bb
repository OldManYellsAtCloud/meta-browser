# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e75b9d661ab0a86e8134ac434811b7ab"
SRC_URI[sha256sum] = "840856bc560240792550ad557b2a6a709c8baceb6518dae6918a2c6d3755f48e"
