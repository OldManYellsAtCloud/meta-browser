# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10c6430f13434b64ffb8cf06b5f53d3d"
SRC_URI[sha256sum] = "269c7665d09923426086772c42382803ed69cc25ca31a454083f7cb8ce39f29e"
