# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "684accbb6e9ed392b63183297521fb3ce10de1e2061b6ca1d0287f55de27c311"
