# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49cb073f84175306fd5f73058647f36e"
SRC_URI[sha256sum] = "17be4e9bb3def783f67855eb37e46174dd0ad3f1210644b319ae29bd9074c0e3"
