# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95cb9c7dbdb652ca28dd85f89827bd3d"
SRC_URI[sha256sum] = "d0328c0390e32700d603a1584151f8a781c5292ac0fa4ca7f43d960ea63d92e0"
