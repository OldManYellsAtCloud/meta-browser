# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e5e0f92c4bb649bac28ad62ce774eea650f5c0d604b87778b309315a96f35e55"
