# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fde4b4aea0893eb20d4a2f38a803266"
SRC_URI[sha256sum] = "36b1fc4aee4433e85b12c3c494faf4cba409bad41aa20abf803c0901278dcfb0"
