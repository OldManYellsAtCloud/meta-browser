# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85fbae592a1fc4cbb88a46de2be3430e"
SRC_URI[sha256sum] = "34c678ca78864c3ae1d2bd6ecbceac37c34884b3f37ba1485de56131c50fee13"
