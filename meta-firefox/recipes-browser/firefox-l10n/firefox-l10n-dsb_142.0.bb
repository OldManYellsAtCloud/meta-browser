# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a003609d92d224de87106038ea2b30d6"
SRC_URI[sha256sum] = "8ba5af03398f99982227c6f3e745ad5590d2d9a81dc1d30a3ebd4c2ee7f8984c"
