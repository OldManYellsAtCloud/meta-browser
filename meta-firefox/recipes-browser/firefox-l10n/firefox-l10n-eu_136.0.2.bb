# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa47105a8ee41b9d9abaa0f3a192ee5e"
SRC_URI[sha256sum] = "e66941d3797a4e1d234d769fbf204cb8039993fe2c1a96f9cd37fd48072c0561"
