# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "abbcc92f49eb0d4a7c5f3c2129c3ccdd0a2187a7cfbb0661490a5cd7fac63f1d"
