# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71f5c8b227212ec394a2b4f4d60666ae"
SRC_URI[sha256sum] = "d40f2329a3f482df519ea455088eadc312eeedd574eafdd5887e9f1c4a6ebb71"
