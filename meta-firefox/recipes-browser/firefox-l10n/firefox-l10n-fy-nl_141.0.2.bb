# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d27d0bd6f23ea8cf1a766c3d2c5b1357"
SRC_URI[sha256sum] = "79a329912747c2e45c9d3e1a6841a3f1170263d036f9ebd66b5a7246e5d38c1b"
