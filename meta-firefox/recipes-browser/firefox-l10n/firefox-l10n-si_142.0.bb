# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62ce127dee307335236aa39360cca15c"
SRC_URI[sha256sum] = "7617f7fd52f7fbc68cc515d2d5224542c910c05a9c77b2f5b431d211a23b4cc0"
