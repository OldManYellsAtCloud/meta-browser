# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3f15926870936d537f808f4ff84b38e"
SRC_URI[sha256sum] = "176ba3d33eb43523e9f64fc8519070f8708c705704f4402a868d40d776e364a0"
