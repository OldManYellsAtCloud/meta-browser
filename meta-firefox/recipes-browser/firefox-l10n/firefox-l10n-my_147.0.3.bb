# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9ed3bfa0f80d3c2caf53c65e3acff4a"
SRC_URI[sha256sum] = "aa7b411f933394f939e5c6a1c840ebe25ee489e5dc0771b737e1ee84c900cd2b"
