# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dc70bb5e39ef6848d377ec93f4cb965201e2e0ea3c5b98fe1993fd55c8719093"
