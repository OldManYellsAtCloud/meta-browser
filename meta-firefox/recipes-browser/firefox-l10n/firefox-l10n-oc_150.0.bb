# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f3484c590b12bd1d5406f91d847e90c6c1a4d87b72b705d21b4ed877d3eab63d"
