# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "068a0a9ada1d530ba4ebb8a298557976"
SRC_URI[sha256sum] = "147bc1886e55b9a88cd34b5a2d8907d4a82a3ad5cf1925a49be642646687ca8a"
