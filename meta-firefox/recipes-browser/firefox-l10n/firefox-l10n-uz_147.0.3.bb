# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b1e2ca164876315ca39de4e7f7ba3a9"
SRC_URI[sha256sum] = "87c1672d7e31b106d304202edc82eff81ef8288cae030d617f9c1e706ff2b4fa"
