# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2e3fe51f8e2a733c132bb3353e43bfd62d82adaa8fe1014edf1d8c4db15020ac"
