# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2e751d3d4148a78ea099d73f0961aee"
SRC_URI[sha256sum] = "5046fb6090a53d9170c8488497d4756cd911fe0dfbbfa8dd37731213a855e2fa"
