# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03d4246366be5d8255101e755200e9d5"
SRC_URI[sha256sum] = "ed45e17919f3e0196589d379b591c3d2cf051b2cd018f28643a334189b128875"
