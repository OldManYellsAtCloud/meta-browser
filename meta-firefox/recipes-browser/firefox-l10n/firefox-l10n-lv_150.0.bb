# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9213ca99bcd4ad28e406abf71f0e55fb6f9cdd0c9e56f7104d0c6decce19d958"
