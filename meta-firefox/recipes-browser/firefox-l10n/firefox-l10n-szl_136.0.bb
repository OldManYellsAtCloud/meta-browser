# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de8b4234e9ec846615e7aa532d2cf244"
SRC_URI[sha256sum] = "80e0742b2a42a95c2be1abdcb1345295bdadca6dee9a9ea84163cbf317476b14"
