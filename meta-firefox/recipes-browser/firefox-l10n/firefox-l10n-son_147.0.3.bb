# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3259daeb9d977b23ecb8858cc15ab7f2"
SRC_URI[sha256sum] = "742531a70b2346d2567886ea803aef761f81a30ebcefde48a993d931eeb9d53a"
