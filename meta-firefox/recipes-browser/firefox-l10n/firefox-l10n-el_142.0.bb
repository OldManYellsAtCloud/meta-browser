# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3af38f6ff6e6c3226eee0c20ef61d2d"
SRC_URI[sha256sum] = "e7be575fe96969a82e76c324526ccd29ed7f828dc56085265750a4fa8f7c6993"
