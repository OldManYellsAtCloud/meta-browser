# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2152f551a37306aa968ddf7160350bc8"
SRC_URI[sha256sum] = "75d9730962af262157db15f29f3b27bfb7ebb5833c05c93d39f8fbcfe9fc2be2"
