# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "af1da6b0740ee5978ded163b39eab7574b9d8306c5d7d0e7e41a77bd50f6a6cb"
