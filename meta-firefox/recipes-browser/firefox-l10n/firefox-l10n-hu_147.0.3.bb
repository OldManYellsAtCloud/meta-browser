# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14c7b7dedfb3eec5c7e1936b422469bd"
SRC_URI[sha256sum] = "a6aa86b1c27a0abb321244b1930f932504fcdb8345bd4d869e8b1e1752c0929e"
