# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32a4508bdb6ca4bf97f68287103ec6b7"
SRC_URI[sha256sum] = "bc18f78cf586df8cfadac34f7ce46f209f26d45a798bf9982447bbe8e3386367"
