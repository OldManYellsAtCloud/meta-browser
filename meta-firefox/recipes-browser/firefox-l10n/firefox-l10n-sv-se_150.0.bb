# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "18afd7fe58f262eaa43f371513ad96f9936ab695f6de92be9319a6833db6d994"
