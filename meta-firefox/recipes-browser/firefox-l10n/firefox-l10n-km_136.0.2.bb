# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a50f763c6d421ab7bbb17224be9b398"
SRC_URI[sha256sum] = "3af65de802c0020b42e6dd426406a38570edb233d98e3af448bcd2a3b1a8f68d"
