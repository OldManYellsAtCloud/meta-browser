# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "864dcd1931a49fd8ce645b90360042ceae9807b3d60e33d15ca1791e5b6bba30"
