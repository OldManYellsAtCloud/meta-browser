# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd36646f06fcaf553fbbca118b667626"
SRC_URI[sha256sum] = "f5b3eebd26d13e09df0210a63669c7ad54a112f3112e04d954936c144cdd114c"
