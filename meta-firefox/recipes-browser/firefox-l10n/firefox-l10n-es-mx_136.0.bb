# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e458fd9568a9ac8448ce94c12ce8573"
SRC_URI[sha256sum] = "f6a32b7338836bab1b139dc6015faa525bb0274d7492c6f5631a94bddceffb3b"
