# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "244d57d41f921c5958377d4acab4cea0"
SRC_URI[sha256sum] = "13cb2ba7350db4005c3928db8b1687ee58b13bd5fd623bd26435b05892b29b3b"
