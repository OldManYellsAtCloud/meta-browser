# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4ead339e57b438ac2a55c55cb34d361b17635293e0145a87b6be80dd53ac6403"
