# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bd6cf33a459080e9cf5281d0591548a"
SRC_URI[sha256sum] = "a879ce270fb8e824311abc41a472245bdb60942edc25b1e1bb2ec6f793a23f6f"
