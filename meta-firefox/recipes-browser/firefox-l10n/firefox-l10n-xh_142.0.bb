# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1565d9c580a32a5b667909130ba4bb98"
SRC_URI[sha256sum] = "cfd35a7e324d7801b9e247feed2ab877b667f8db5c3097a156f59b8b004479bd"
