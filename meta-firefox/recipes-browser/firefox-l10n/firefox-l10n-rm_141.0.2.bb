# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "991dfc6556ee71c8991a50a980be4c18"
SRC_URI[sha256sum] = "33c69b3c27be3b32c35a5b592d7f9b864d19e689447688f0f909d46c96b721d6"
