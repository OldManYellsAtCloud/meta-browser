# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee5084a0b224df63168ec1f8b44e20f2"
SRC_URI[sha256sum] = "273a7ff1f1a6ea2ddd95c3984958833bd5f09b03062d8a04ddd3278346d8f41b"
