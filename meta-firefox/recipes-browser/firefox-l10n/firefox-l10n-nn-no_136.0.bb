# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "098bf0b6571e1b11553bc92a0166e8fb"
SRC_URI[sha256sum] = "d904ba8bf4e92b1b41a452e034e650b7b845b85aceacbc91c03247afcc3dae0e"
