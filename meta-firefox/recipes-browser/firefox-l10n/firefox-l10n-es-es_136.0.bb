# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96959ace0e279435d1a49e261b5888e2"
SRC_URI[sha256sum] = "9d17b5b36a382e32006b14e704692fa729e99c8e82f926df01c546bb1d4bb725"
