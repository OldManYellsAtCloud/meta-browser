# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d3be4a608de398d23eac18307b9d68b3bc887a5d349dbd09dc360fb86b941583"
