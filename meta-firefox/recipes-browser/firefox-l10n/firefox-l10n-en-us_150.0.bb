# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ecf36fd32f42f2524f43de078c73a185df9cb9c7cff859e0aea518556e626599"
