# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3a3ae819478765785c2c21bc2394c1e"
SRC_URI[sha256sum] = "2d6a9386248fd3efd299a043d2a0432d30e0a28628e339629b0f1e32916fe1a5"
