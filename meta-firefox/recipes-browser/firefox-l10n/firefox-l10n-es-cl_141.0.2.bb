# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "858fd12e7d891da42befd6311d64dce7"
SRC_URI[sha256sum] = "a91be48ca639e0bec431bec672c958e1a81d49423e719d74417547add2c06b70"
