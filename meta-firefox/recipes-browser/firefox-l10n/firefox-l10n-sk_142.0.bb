# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fe9d91d8b74055802e5a7543f32acd1"
SRC_URI[sha256sum] = "e0c5e06e0b6aa53c1ec6d9621ba55b0dd09fefd62b7232f7c295e9af95c621cd"
