# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29c1533dc1bd0fdbfae631542c8ec465"
SRC_URI[sha256sum] = "5840b7afa93f9f80e67f5c2a88706950b10d3b2351dc311bdff428d5908c6dd3"
