# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3a513c3604c11829369917a642de55b"
SRC_URI[sha256sum] = "d7472e949c1baf5171efea0422834f8e95a8974387aa3c8a18fc51cdf323a1c7"
