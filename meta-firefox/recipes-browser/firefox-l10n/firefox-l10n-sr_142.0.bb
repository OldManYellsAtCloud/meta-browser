# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00c4d93ea4cb304bc9bc41dd8cdd03cc"
SRC_URI[sha256sum] = "388e3f6e916cebcbe79b64338e1b1fa788ae679309a71ca31078add2b7783373"
