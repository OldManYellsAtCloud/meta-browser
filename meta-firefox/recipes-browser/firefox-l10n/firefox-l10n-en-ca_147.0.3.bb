# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dcb27624588046ac5d26f5e8cd46a60"
SRC_URI[sha256sum] = "b9c42b3a562e4437c37b3d4fe1870985f2157f32566769bee1df83d037178d38"
