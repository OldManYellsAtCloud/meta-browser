# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9ea699867e943fa7f695f010ffefade454ea39dd6a61ea258407143ffa5f267c"
