# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "624a71a949f8dcabf11c2c593f1e16ff"
SRC_URI[sha256sum] = "b300d4bfe32b2ea3696f9f70b9b506a0424d1f3a4e962c97e19443659ac1560b"
