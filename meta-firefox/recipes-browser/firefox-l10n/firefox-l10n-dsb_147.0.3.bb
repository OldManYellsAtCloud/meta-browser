# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62a3c6ce6a82b45b66133e16d1684161"
SRC_URI[sha256sum] = "f534efa98b214bca0cb6a57a261345f8c6e6e14ed66ef1a6e4ebbc4f03cb6889"
