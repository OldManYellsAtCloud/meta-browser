# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9effacd4c55ce4af84f527bdd9f0b317"
SRC_URI[sha256sum] = "3dcaa331906b44aa748d6932b50927c9e6f6d5bc341177dd01f29a401378448c"
