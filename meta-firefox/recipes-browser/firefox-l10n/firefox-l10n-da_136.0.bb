# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25701d38d4eb1b094674ee9644c86473"
SRC_URI[sha256sum] = "47a5ea3758b5abc958074c1283568211edf235e72f7fe68059f01a470b303852"
