# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64e228a37c066870a282da15d97f7e75"
SRC_URI[sha256sum] = "375cfd5adaf75ff867b70b8d48a53c5223a2c50f6ccb2511b5b84475476b278e"
