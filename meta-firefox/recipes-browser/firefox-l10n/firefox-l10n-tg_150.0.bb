# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dccc39bc101c6eafcde24331acfe9fb6a6c84b2a713fd30d461ef3fff8cef240"
