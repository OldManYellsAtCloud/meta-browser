# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee03b47dab535cd551f79568fafe13ce"
SRC_URI[sha256sum] = "bbc7e7a35829baf63973f51c1e79fe5b50dd32a5e2a7752dbdc1da76534fc584"
