# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45f3ca1ce3c86667297c40ccf4fb9f77"
SRC_URI[sha256sum] = "e5ff4ea44d13719cddb039fd98147d93482d2b101375936c69e482506030127c"
