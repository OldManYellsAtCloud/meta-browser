# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9cb4c18c303698ef2aa8f1219a647da26d878daa6f5791185ddc20c5a67d5b08"
