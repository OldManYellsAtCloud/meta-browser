# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55217abe1871139ca5668c135aaca4dc"
SRC_URI[sha256sum] = "bc0b0f88e6386bf802221957000778081d192a4e094cabeaafc84cea7e6c2cf5"
