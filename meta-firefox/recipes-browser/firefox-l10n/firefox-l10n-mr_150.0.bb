# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a17acc7e69bd82730e3809052f1b0f9bd096af895820107084f124b32d87cca6"
