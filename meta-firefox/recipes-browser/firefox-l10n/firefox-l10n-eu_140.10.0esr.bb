# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "da43ad77c93cba332cd76560e51469f9ff1dd5a3bea149bae946263d3c495aca"
