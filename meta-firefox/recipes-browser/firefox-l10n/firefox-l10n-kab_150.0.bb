# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cd549716037c8c01e6790ec9e0d7284fa93e2ad18512eca1514fcd5e8e306234"
