# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "127349ef5f647e16ec6d11d72221b681d66f566a6cca49c50894fb53cdefb49a"
