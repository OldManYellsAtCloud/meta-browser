# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa18506b45b36905d499f2e9c65bcbfa"
SRC_URI[sha256sum] = "cfd1b4f066b3c90c229c2b152fcc238048a07a82cb6ad038619be5df9bf934d4"
