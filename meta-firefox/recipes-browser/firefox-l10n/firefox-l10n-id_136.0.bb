# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "388f654c8598e24cb1c625d2da85cdb2"
SRC_URI[sha256sum] = "d11638282426722eedd73d91c5ac55a6ea18d2cd4fac68a6cd761d558003dc3f"
