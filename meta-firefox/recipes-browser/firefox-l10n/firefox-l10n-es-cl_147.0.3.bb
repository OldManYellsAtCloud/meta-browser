# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f5f743556d12457bb72b60e3ef89494"
SRC_URI[sha256sum] = "899b290732255802f3a96d7f83cbf6c6883a1f49fc23a6e13301502394e4f618"
