# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6a3b251df7dc8b7435d2afceead784884a06d61c610245181de0db1d019f4787"
