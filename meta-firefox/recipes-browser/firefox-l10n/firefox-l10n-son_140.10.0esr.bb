# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4209735ee0db05454410086883e10dc77134ff58e71ee19ce914e61ba24bff4e"
