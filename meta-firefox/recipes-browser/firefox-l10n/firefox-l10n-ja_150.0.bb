# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3af6caa56574c1d7e7fc4d71740957e2dc405a56be1bef58f1bb547017697693"
