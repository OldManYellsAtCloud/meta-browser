# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3177174c4af120762d6fb3dc97ac62fe"
SRC_URI[sha256sum] = "0922592f1e08d522d9c9717d365be8957efac017bf5c9e8e9c2572e43704a8fe"
