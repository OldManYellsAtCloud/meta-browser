# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "09d4eccc50019357dcdede0126e5464d05e854d9a7256d798265225d04b2ec37"
