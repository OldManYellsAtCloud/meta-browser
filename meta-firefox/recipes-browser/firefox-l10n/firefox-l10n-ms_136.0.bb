# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cd94ed92fc40eb9650556bbb9a0c57d"
SRC_URI[sha256sum] = "0a86ba2eef0aad4dd550f7d292cf17d0a8d6cb2b1b1744000f48c394639714dc"
