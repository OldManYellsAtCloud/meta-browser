# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b19ac68d9884fa67078f34a7e6c06d4"
SRC_URI[sha256sum] = "c98ebec993a2f4bc15a2e873ac9d98de09d564f3a9c33bfc0abdbd07c9388ae3"
