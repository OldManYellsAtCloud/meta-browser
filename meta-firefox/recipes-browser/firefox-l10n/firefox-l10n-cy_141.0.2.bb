# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1691c6f59aff51c29a272b387b011ab"
SRC_URI[sha256sum] = "fd398d5e8a81fd3f4dc2e18de25a29e168a52e140b06b61b256727e6e7ddf4f5"
