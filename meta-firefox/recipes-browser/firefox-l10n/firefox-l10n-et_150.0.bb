# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "94ab8e183aa5af547ba6962f8a013fc159f26e75ab298071005ab1bb1cd25c15"
