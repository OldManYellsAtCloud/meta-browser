# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3148b821f92e8d05b76195565fa8a12b"
SRC_URI[sha256sum] = "bf135e250cd5008271f0b6dfb1422ba5d27495f389634439fbe40e304016833b"
