# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9674f4df6b2cde1acfec77d23e81fee"
SRC_URI[sha256sum] = "e6e1c72c0abd7f6c39f0012ed7e24cff0ac0bde7a05dbf9602415179a49a099a"
