# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "089c5cbfcd50ffaf152511c2a6cfd7ff"
SRC_URI[sha256sum] = "ad8ce2a62df507e0f7388cb6f4464833daef66b842f09203ff0a6f0d8442351b"
