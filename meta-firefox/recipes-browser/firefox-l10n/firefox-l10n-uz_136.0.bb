# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b76f4c3349adffa7a5c946a7572d189e"
SRC_URI[sha256sum] = "cbb21fade7a150c0016a7a75f9d77348aaf2e2f2226cad1dff36111fff439ac1"
