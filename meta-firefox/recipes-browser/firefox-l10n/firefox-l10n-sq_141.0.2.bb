# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d8d2838431194b7e38e31593b6b0598"
SRC_URI[sha256sum] = "8e900eb64ab4d4b1dd0b295700c9e4d8c076ab0ac48cf8e37aa49f3ac8404384"
