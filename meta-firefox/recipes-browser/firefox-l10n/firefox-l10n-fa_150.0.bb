# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "53ed7d5cb429edab2f344b15c3f7e5595fe972e7c91958be9b364deac91c89ae"
