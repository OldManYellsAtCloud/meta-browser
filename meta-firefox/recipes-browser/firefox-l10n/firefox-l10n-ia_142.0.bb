# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdd1063c8fb8228d8e763f4f76080041"
SRC_URI[sha256sum] = "fea0b1f2f543eb766df9fc9faac81780ca907baaa6074a49b2aec512db1a206b"
