# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64feae6631e56b1db9b76cf23c7b33b7"
SRC_URI[sha256sum] = "ecd0654c717fde205e5bc99a9a556e4666ad46614b1256d4157b893c2b25922c"
