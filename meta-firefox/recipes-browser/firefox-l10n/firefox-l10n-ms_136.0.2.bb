# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fae187765ccf5845b8f392917dcb133"
SRC_URI[sha256sum] = "933b61586d447637800a08dad1f52397c4204968c3ab484fc97f727fbb61390a"
