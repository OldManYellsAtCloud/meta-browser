# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c6ac0883e37b61d33aa7d9d9237c282"
SRC_URI[sha256sum] = "1063bae9b818351638c41f077827a9aa377e3ff441b646b3ed43d28f323b7ab6"
