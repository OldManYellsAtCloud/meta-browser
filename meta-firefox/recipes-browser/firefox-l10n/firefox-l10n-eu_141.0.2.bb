# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "477aafb3eac5108e77d7776862bc9a8c"
SRC_URI[sha256sum] = "88eddbdb3a71d667fec675677901756a608f14501bacbb95ce662e392f72514a"
