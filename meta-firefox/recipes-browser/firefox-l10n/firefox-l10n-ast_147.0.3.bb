# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1894a78c91ca85fc3b5c02bdc7b0272a"
SRC_URI[sha256sum] = "b7345ac134a5c873a19723ee803fc579384e732c8bdd6cc5ae1d6458dfec08b8"
