# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baf2a56264b0fa9c83f96021c731238c"
SRC_URI[sha256sum] = "020bf4748795d22cb257cbd1af058decfe5b476dc9b333c554e912cdb80a3d5b"
