# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3eeac243dd67c116e713cedcf7de809e5b38f2b90c9ce2396625edfd7f523b94"
