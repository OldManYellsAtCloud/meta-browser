# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "901e70c1bcbe261505380bdd5a571ec5"
SRC_URI[sha256sum] = "b8e88c990f1cc1360f2e35c2e8ab28865505ac70b5802e8956a80815086e55b7"
