# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10748d774a244ad90edd55358354dc79"
SRC_URI[sha256sum] = "2a84fe369d27089b83df31dced3ac0dadb5ff411318a5a9d740735827c62529f"
