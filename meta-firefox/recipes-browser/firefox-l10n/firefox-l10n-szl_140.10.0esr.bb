# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c474c1b201478f300e4194feb8606f84d7709d1ee58e44718b3b1f3f1a191f99"
