# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "926a5e446bd75311b6875827f513007b"
SRC_URI[sha256sum] = "32c5a14dbb56cb01bef5bb80f01b312eb09443b33ad8226900ec445a2af33e99"
