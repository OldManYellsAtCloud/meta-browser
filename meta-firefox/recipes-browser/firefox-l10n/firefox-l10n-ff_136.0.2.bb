# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8586cbb7937eb559298392770c234109"
SRC_URI[sha256sum] = "ab8b340846847ba767732fc7b3032a8d72324a92f1fb046acb83d99099e1c20d"
