# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbc92d4c278b48f764ac9814d8db1fd9"
SRC_URI[sha256sum] = "448628754a9f606c2f3bec89e09d2db8917cc4beaed3b9d447b01d36cb10bfdb"
