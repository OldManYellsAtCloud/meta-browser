# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25ca852bc8b6e4a487bdbba3b4981163"
SRC_URI[sha256sum] = "de59c5871e26c52f7ba7e1df82c9e58eea3f4bc87c54f162170a24e67f0685a8"
