# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "071ba118a1a163bce77a6ca7a6eabcda"
SRC_URI[sha256sum] = "3f59e5231552d9f7cb4f02fb75dd1be751df1552e420a993a20d88d44c1afa6b"
