# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "87b6e41708c8ecc6004c697c7dc94b6c469b90a3050fac8e07785dcfa65adda3"
