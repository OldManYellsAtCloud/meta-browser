# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4a2b136bcfc11c234eb31062ddd52af"
SRC_URI[sha256sum] = "947202f9d0eb6c1ba54d71c01406c8241c9e9a4fcde7571a393ea01085b84b2e"
