# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5757974a97eaeaf12e92954d67c09eff9bfb2f41a0aa1977ea52777e23d3443c"
