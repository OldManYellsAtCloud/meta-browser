# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5c86b7ca2046ad48f16193241952e25"
SRC_URI[sha256sum] = "7bf2e924fc12e4a308ca7bf8e44850ac8aa6068242d1184bcf376c314189a75c"
