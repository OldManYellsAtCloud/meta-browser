# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99a1f7d73da82738c9202e3138d0c113"
SRC_URI[sha256sum] = "f1fb953f1717c3099145412d86787c68a0c14ffd2897f040a0247d76624b8c07"
