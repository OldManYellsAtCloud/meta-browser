# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "de8ffd926cdc130b11f02bcbc0f045af13e133fa143a148b69c0e7c243fef89a"
