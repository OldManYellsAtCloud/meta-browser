# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c52f885e20705c34e6235a0e92e09a27"
SRC_URI[sha256sum] = "0706a7795172120a6bb34f90a284d9fdcbd2e2839bd86731c2bedf39a2ce9d27"
