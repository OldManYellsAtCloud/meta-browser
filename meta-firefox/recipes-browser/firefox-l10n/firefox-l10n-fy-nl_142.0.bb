# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fddbda726ba7fc100803f19fa79b7deb"
SRC_URI[sha256sum] = "0c81057c5373c4729a7ba9fece0c77719aa5409c41607a8f544fbcb405884192"
