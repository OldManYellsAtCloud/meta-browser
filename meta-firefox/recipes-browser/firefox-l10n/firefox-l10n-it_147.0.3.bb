# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5ff6d328888521b99a36cc0ac4d6a73"
SRC_URI[sha256sum] = "fe2465bf0814b8503baa801ced4b2451eb765ccb3412bafb188df0c1d2a7d857"
