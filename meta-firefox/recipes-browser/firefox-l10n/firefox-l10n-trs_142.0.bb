# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7abe846ce3410ac9ac2ead4aa57c8b10"
SRC_URI[sha256sum] = "da476988521e771e5c8487a47aece06570ecbc31214b5797428e2e53a057a1b6"
