# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cd9ee73a3fd26a1910723249afbc953"
SRC_URI[sha256sum] = "a97e9269e203d35ff82e6cac7e4782d18fe5462b70e7ac79dd8829513ab910c1"
