# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8141e5710b8c22511a357b72e37298dc"
SRC_URI[sha256sum] = "6a1b52225a716c7ba7d3074649a2c8ef6bdbfbc09e3ab56334ddc36b051dec21"
