# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33baa72904e1b336e7747a29303a9a93"
SRC_URI[sha256sum] = "b91ec862969fa3bb75b176e44edb6d41ce8688bff7be4565b5ed4dbd49d17175"
