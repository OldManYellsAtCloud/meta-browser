# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac9c0355b1deef05b38ba7e12f7c3644"
SRC_URI[sha256sum] = "92d640098e478b9a00b34928ac13891daa64dbe0ace934500b9b49b31bfcaef9"
