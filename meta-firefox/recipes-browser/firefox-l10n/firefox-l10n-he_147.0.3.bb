# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfe8d7210a4a0fa608d985ffcd89b3de"
SRC_URI[sha256sum] = "7cecb373e962a60692d6f5056fa22a8d49150d77be55fa625268824925b8704f"
