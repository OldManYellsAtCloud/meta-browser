# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc37b7dd80045a15c2cf5f2a9c0f9b2c"
SRC_URI[sha256sum] = "a278e0860bad11b79b8d9f305b3a57f20b7b06cb5ef032d940807bfd194a161e"
