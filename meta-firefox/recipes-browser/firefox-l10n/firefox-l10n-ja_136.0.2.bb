# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4afb6e915f8dc5cb766a879d62a59ba3"
SRC_URI[sha256sum] = "ca646bb0c27c792c47dac885e3ac97ec5e3b475a26aff69b7f917126fe139608"
