# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe2a20bc7f01d794f995f9fea2c895fe"
SRC_URI[sha256sum] = "a34dee8d94bf75bc6350b414c9b0114659ab11f0d53d59838fe8dee8acb85ea5"
