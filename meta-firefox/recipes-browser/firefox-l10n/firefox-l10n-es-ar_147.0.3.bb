# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25bd079f39df337ecf3f3794b632cc0b"
SRC_URI[sha256sum] = "56dc61e435f5cf8c6a48dd7e2045c6eb80b76266211310e1141fe0b9d72204e3"
