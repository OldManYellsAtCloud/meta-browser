# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c109a4564616081d61585eb3a9ee8ba"
SRC_URI[sha256sum] = "6e82e441737256fa77686d8ba0e21842a01c56220fa47079adb9719b524a1d45"
