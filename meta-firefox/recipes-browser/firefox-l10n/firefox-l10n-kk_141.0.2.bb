# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd191545dbaf23b339188e9ba738ff4c"
SRC_URI[sha256sum] = "6637fc969548ed01a0ed461e2510f5f62239b68ad80a22e21bdb86461b8777f9"
