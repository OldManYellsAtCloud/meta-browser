# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e23b4b45e0e0df43d61dc5c2cfc5f5e7"
SRC_URI[sha256sum] = "9bf690c6a784fd90d6a668403272fd553fe93d960a4370639bb89fb6813cff62"
