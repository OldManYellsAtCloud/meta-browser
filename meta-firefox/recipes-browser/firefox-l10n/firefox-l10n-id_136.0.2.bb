# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a96fe9f7b17ee440c8692d48e68aba22"
SRC_URI[sha256sum] = "a73d1c0dd76d32007251b73aec8deecdc699f72c6f25f0f2b87a31af120b26a0"
