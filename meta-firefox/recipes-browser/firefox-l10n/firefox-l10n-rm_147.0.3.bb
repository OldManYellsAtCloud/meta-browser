# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb1573db5fe9ab39f21a450d3aa19ce4"
SRC_URI[sha256sum] = "063c6802c6302e6dec36431265400f798960050237ad093985c76a0adc13d81f"
