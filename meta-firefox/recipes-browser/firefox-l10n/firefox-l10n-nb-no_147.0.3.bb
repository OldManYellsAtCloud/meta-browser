# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50df5032ddc39d0da475948d384a5073"
SRC_URI[sha256sum] = "5868280cebec3b9b67e48d47337341178eb6aab1bd091696de9215eab74cc89d"
