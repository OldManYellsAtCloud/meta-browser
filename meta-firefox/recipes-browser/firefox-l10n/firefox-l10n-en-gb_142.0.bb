# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb8e33c1f2339bda2a9194e449a6a0f5"
SRC_URI[sha256sum] = "30a1386825e1de50835e742fbfc96765a2933b075683e8b7afb8bb2da41a90c8"
