# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "256a26e1e81a8440587b3583a010e33f"
SRC_URI[sha256sum] = "95fb6ef525a3ae65fe9653c8a9d2a419ccaf4d1b028307b03cdc9c42f677a392"
