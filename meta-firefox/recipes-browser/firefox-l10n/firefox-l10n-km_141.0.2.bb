# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6297741d92dfc66935ea22b7d21e3a7c"
SRC_URI[sha256sum] = "a1a2718413d666ddf63d9aba0128e86308520a73ca197175a18ef1c45691fa38"
