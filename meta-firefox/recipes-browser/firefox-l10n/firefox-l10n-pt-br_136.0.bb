# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45a5139a22e23c880dbcb16bfaf6b34c"
SRC_URI[sha256sum] = "c18f38d93a774377f96586a961fbc188bb9ab3607dfe3ef274704ab1d2acee75"
