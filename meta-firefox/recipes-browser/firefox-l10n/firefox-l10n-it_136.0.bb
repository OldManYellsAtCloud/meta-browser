# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "048b57c31821ab84e882a6729e4b002d"
SRC_URI[sha256sum] = "fde5c281e34bd5ad1ebd01b05af3c1a5ab9b51d191abb8806c457948462a5fce"
