# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f773d9e7e927d3ba454231e6a103a2a"
SRC_URI[sha256sum] = "2370ec58320184cc561726ae48b7fbf026c724e90b0eae098133217f7a74f936"
