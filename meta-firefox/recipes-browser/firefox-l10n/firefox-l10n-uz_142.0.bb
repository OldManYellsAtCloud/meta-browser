# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b06fa5a5f89b756ef043967cc78b925"
SRC_URI[sha256sum] = "f353718c556a4025aad2dd68e434c6d4f8d24e428f8d631fe9e70a7add2014a3"
