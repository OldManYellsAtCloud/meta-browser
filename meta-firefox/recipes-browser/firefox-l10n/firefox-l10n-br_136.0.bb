# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "859680d05a60299029b2702e100e802d"
SRC_URI[sha256sum] = "cbb72711fcf224d13212caad8894a94d1c225486cd38b64276559c4e865e7918"
