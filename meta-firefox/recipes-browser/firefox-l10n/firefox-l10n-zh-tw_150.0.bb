# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d253d6bbee89dd74dfce8e6fd2495e400e038b8bec8337dfb5f88eb99d88087e"
