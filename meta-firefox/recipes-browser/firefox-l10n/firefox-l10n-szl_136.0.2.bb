# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81cd45f5a017eeaddba9f4d2df2a1f3e"
SRC_URI[sha256sum] = "03db06bc0c4f903b0bca0e5223a61dbc1dc706791887fe5939fe0c6869d153aa"
