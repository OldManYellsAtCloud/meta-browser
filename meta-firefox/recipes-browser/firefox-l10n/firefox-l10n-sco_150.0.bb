# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "282fba390de05d968666f2ab6a80f406a88f52f442f08fc25890924104326d33"
