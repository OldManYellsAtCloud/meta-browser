# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d833a1174a61125bef081c08f06ddd711c4169c7e3c16b24236f969faa244bdc"
