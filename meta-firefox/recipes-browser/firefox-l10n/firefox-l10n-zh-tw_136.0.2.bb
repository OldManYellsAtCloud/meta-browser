# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6f37776f649ff17eba430aaad600233"
SRC_URI[sha256sum] = "62aecc5e853b6b6b9c8ac54ecf6c9f6e03d78fa0a5ef515088be693c786e0b35"
