# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13e08ddc4b28df927afe3ef88025936d"
SRC_URI[sha256sum] = "fbcaf8b5c3fc17c9f37f29f42728852677cb02907ddb67894d266e63572c3874"
