# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ee479d8b31fca278e2a335b824ac1490665e3a4649b7f3b2a0335270e52642f4"
