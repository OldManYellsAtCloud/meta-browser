# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9068949e401e8ef8e2f0e2bdc2f824c9"
SRC_URI[sha256sum] = "79559abf1ec9a99b0c21638a30ae9df8dfc7717dadf3565acac415d3019353f8"
