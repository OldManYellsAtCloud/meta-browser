# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42034f26883852253cb1a266d7921aeb"
SRC_URI[sha256sum] = "b27c332da419d962815443c45b1494dbdf3182ba6f94c382a770dbe6a001a3b0"
