# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d5fac4d7d2aeb28032d03f93070362"
SRC_URI[sha256sum] = "5d5a1690fd661d02286cd151558de56bf67a9b1677e6886bec1182936447de37"
