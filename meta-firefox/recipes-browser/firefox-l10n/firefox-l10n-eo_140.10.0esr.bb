# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1033ce9c3d62bd5b6efae5eccb0ba6a9e9fa937ee03262b757d987dc19289288"
