# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50760dd2bd5ffd29f5bb1d77daab1a60"
SRC_URI[sha256sum] = "3b2f7ae02c9271a9a19e5fe8f3df2ecc9090e9634d7cab882682d3be09b10f3d"
