# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feb2f26bd984728f72ece4f09eff2311"
SRC_URI[sha256sum] = "f57bb048069b14f65d291199ba325cd930af4d6cc5a3d8dd0a9f97d0ec2a3113"
