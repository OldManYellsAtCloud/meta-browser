# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1bf222e9939f87f3b613b86e8d1f637"
SRC_URI[sha256sum] = "77a8e9c87ece8ece72c81873a38b07f16668e8d15b46b367b6330751e77f6b32"
