# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca761571b7aacb03bd21e0dc4e95fb2d"
SRC_URI[sha256sum] = "5260e9e7a7a0499ec5eef412b73121dc635ae9fd33757cb8c3c01c08f8eaa010"
