# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "825ddbcf5e4175d2947ae938aa6e2a87"
SRC_URI[sha256sum] = "04aa2073427eb6c63300e340649ccdc75b1bac9eea63568cf5ff615cfb19203a"
