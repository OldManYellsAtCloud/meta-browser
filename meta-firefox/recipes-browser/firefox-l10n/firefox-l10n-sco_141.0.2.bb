# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eacdf89ac3b658d6cd69bd15846f92ac"
SRC_URI[sha256sum] = "759629925bbdf133cb3979ade415f69f079f125514d596d1778d3bf5f50f344a"
