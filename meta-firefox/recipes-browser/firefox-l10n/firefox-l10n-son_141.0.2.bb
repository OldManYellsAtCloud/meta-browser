# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3973e234d9678bf6973f98133ca2785"
SRC_URI[sha256sum] = "c491e761c979f7de59d39d3a0392b8935a2e38968786a1e70f534e4ee7d2741e"
