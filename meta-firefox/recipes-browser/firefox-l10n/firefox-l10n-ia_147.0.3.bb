# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4077e0430330cb75f4ba4e07f730f368"
SRC_URI[sha256sum] = "ff72b5ac902e9278b24f5f4f08b877da53e2a19b3f4b615ea001daefef37b23b"
