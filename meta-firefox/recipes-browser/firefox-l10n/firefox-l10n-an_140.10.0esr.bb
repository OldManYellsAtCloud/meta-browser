# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3b1934974ba7c79af18479fb3a6bee3b54a6ab54dc790a0f308d8f37de22904f"
