# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "483a5579d562704af00cbddf80ad84d8"
SRC_URI[sha256sum] = "fa31c5b73eb35c79824336770e0fbe4590f0a127b06fa9b46f65bf1e5a0cc3d8"
