# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e985a57312830c9e8cb6558d2b780bfd"
SRC_URI[sha256sum] = "eb6e7f5d4f870d137eab875cace627d60e852293a113c50a4904fb8985ebb834"
