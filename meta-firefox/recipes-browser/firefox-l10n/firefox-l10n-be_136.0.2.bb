# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44910c79e898ac7e70201f2f07e6fea3"
SRC_URI[sha256sum] = "8c4e349fc4ab789ca1407b779cb005147e59d47be1a358215579f7bf07751394"
