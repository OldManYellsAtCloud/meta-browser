# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2056fc53a5c81e1dba7f9c1b7738c2cd"
SRC_URI[sha256sum] = "5e8d7c36eeac1601b74bc75feecddbdcf097a9284224d1e2b64e088bdfe28738"
