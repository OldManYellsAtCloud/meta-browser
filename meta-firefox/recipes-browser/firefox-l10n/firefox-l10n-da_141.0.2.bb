# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25c1f9af65cb1cb8a03d471b652a7ce9"
SRC_URI[sha256sum] = "481a370ca876fa966880347654d8009ef1f49ccb21d0769e54224e2cda1c2fc7"
