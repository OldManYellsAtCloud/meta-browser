# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "238855e3ff3e7e780503ec887c73a80f"
SRC_URI[sha256sum] = "e15a0700db338f3c8c15af479445fe73f0c01b804a5c44498de9f22fd6eb7956"
