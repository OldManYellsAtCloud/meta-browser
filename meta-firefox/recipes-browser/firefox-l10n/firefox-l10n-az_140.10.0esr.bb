# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2635bacd00d4cda81e4eba35968679b07df31908d9294186a31f86b5a974aed5"
