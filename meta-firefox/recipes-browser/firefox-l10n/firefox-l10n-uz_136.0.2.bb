# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b11da61b70fc34ae0dd98a135f94cba7"
SRC_URI[sha256sum] = "e96faba44c8c5f45c872f67488c6ae214477afcfe985bdbfd6fd78e7594b8e4c"
