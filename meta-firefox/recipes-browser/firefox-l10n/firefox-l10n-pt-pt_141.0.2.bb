# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4583d9233e9dbd9856eb77cc25cf250b"
SRC_URI[sha256sum] = "7f5e549a12e57f60c4a8c4fc23cf6cc9ba497da94ce11ece7f1b82a9da10bc27"
