# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b7c0c1474aa5f02fd071a06b2e81ffc96d4ad1a58dce21cac2f4cb5b962cbd9e"
