# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e00590135be9dc98738fb639cb4b79799d65e221170ab93fa1fdfa8ce092d9d5"
