# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac2839a491323daac3ed7f2ef6462ae9"
SRC_URI[sha256sum] = "0ba631095a6abb2017f4d4e9ff2f922ca7898042e899b4b35ef077b66f8c5ddf"
