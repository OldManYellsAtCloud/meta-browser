# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "13c960b16600923c24df911de2b733814eb533f020d0d0325fb16da0d2587283"
