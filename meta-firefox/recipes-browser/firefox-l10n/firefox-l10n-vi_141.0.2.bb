# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df4b353d1babee9b9bf05362c507b210"
SRC_URI[sha256sum] = "653b86db17b0fe45f25603de83f549be0ee1a603ad89ec4908832b787399a64a"
