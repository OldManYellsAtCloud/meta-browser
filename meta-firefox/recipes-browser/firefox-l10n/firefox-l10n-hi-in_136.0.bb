# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c15ba289d476eb77836c797a4392642"
SRC_URI[sha256sum] = "992f3d30caa99be63f70255de8c7da831891524a02e453d6a7f8c8ad9b0c8932"
