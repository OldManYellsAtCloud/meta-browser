# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d5ba1dc6e9f901f285469a23125a029259420f2e209ab04ec8d7ac3db43e990c"
