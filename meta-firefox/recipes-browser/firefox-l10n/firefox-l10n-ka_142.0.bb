# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9e92940986a274c9d0692cda6f6563b"
SRC_URI[sha256sum] = "87ebbc96b04a1adf89190b8d7feb2979cd15cc8ad2a29640ccde35341b9b2ea8"
