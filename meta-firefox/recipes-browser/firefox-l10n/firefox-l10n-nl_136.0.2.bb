# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64866c5244dbdc3086d442518ca40f0d"
SRC_URI[sha256sum] = "55aa0c07bd7249031d53092345180e57530c6e34b02b64e6a10969b88e99b210"
