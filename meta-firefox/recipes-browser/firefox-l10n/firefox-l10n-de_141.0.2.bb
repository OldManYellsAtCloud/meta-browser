# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "629f0cbb8a0fcad8dce44d2b85165173"
SRC_URI[sha256sum] = "f8c50d5095923383b85f1637df8ad88769dca6f22dc44b617140245cbbc8bea2"
