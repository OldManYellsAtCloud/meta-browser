# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8db74ecec113f2652990e4e8e070f2c"
SRC_URI[sha256sum] = "6b21b688d2ff0a8115915ef604254f6e42f8afbb8bed64ca911cefa1299e7737"
