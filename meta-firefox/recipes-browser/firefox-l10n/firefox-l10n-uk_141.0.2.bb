# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e456ef461dffb79267823326c0b4c1ee"
SRC_URI[sha256sum] = "025c7303e3d49213cc7b71245ae510c1951c431445cce9515ddcb95f4f559166"
