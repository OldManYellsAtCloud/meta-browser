# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13ce0376b60701c5066a2c57dc4e621f"
SRC_URI[sha256sum] = "b4fb060b1b14c02a37a9630385ad18ec10b8ddd54cad3ed0354563e2f1485b6a"
