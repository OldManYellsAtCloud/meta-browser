# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "90c1a93d2c8d12883f3dc925a8bd62cf2cfc8e29a361ea666530e16559c111da"
