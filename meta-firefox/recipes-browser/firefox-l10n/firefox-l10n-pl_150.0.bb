# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5e82374e365f4e3f5ba457e03b3b9ae04f036528659a970fe9d5ef8e204fd124"
