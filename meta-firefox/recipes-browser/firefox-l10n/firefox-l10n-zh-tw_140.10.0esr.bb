# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "70c3370ef021a11e2c58e2555415748cf96121a4f5bfae02deb9900716ef06cd"
