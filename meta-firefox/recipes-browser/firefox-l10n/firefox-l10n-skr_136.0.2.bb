# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b622cd6db759b3c3676be105315ed593"
SRC_URI[sha256sum] = "c7593af147392ec261b6b1ebcf483780a79f3b808bc3f1a301f3983425e3d579"
