# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9117427a5c03fa3a0292403281871e44"
SRC_URI[sha256sum] = "0a4db14752bf392a7b1eacf5ad77ac233dafc962c2446fa3a1cad8eb44c49d5a"
