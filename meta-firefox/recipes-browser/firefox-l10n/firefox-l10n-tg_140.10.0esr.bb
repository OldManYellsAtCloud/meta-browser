# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b6d8fe55fc4b5bc6498a271578b61fe652180516c143674bf0efbf0830cd5b8d"
