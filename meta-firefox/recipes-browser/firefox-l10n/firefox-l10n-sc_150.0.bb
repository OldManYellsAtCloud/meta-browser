# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f99fedf99d9604a031c0cfdcdac63f146aa70b62981ee5eeda075a375a0a1b3a"
