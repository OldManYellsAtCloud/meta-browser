# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1787d4b9f2e348340e9c4191fc35c4f7"
SRC_URI[sha256sum] = "ac17890378c9735193223406d696348d2c00912ceeff3155edb185e3c4a49850"
