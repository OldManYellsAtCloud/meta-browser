# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd8fb57110340e72fb1c177f0da72d0e"
SRC_URI[sha256sum] = "3c19e713ed1be698d2f07298344517e58b494437275082780d9da6beefd9cd12"
