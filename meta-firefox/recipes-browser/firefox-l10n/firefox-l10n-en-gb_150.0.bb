# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "73a374f88cd0688a011f2add04a293af0e30a13cf87a65e21c6d66f213d2d4e0"
