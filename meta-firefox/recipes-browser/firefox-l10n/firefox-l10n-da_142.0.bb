# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "226f33e1ca6e5d0824f25d8d7d5a34f5"
SRC_URI[sha256sum] = "95faec753e23bbdca1338b1a62a3eb4f765c7532cabbd5e1635145ea39752427"
