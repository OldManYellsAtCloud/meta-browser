# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "587aa28401a39ce026bea02290705188"
SRC_URI[sha256sum] = "aa69a12398e5bf9f28f67ac1c8f9bb480ef9d8e0b8919e22255c6e41fa55b19c"
