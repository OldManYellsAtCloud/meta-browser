# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f284ae3903be6a827de8336f30ebbde"
SRC_URI[sha256sum] = "42e4d842be745402564682c82cced6c140548d6b8d262862e0c9d21023338501"
