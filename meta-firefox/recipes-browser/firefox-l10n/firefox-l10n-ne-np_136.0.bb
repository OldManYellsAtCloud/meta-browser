# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31f243383321ffce4517800641378f7e"
SRC_URI[sha256sum] = "1256371a09549371f8dd34dfe757b9e4196704ba9d533e22821aeede0a8d0336"
