# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6fa11cc62ba8eba374df035602ccd8ca12b63edfc73643cc307946c64367fb42"
