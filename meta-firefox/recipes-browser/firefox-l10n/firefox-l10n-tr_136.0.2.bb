# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b75a26962a0da8c87c28cf48090efea4"
SRC_URI[sha256sum] = "2b50e409596aacd30ea263375d475e5fef9c97955adb7a38f971b20df1e59ffa"
