# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82eb00b006c7129deec87c6322196e7d"
SRC_URI[sha256sum] = "60d77e2b796e5a19298f6b90762d4986711d803e4281ed02d572ee34c083f799"
