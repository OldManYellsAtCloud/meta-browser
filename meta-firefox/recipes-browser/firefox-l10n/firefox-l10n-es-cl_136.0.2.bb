# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0edafb5415870612c195a21772e48e3c"
SRC_URI[sha256sum] = "6ef9582d88f40f4d5d159cd955e9549c9eb625e37b4a5aea6972587293494b35"
