# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e264843d9b5d8e0604ef12f7c7d6a0fd6aae5ca8f9211ad786b38ac4936c6ab1"
