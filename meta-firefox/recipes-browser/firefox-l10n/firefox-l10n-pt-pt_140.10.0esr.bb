# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "592128f1c537615fa7ccd38c1c1e9ef64bfa062266c4af0800fb0d535de49e11"
