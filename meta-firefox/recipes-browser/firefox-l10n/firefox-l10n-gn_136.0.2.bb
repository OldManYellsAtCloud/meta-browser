# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e199d4591036529baec6e2a573de619"
SRC_URI[sha256sum] = "3e2ac2972ba2b1eada034003abd93d0f6dbfa885ed01a1f7e7352e49ea517cca"
