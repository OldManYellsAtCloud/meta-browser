# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0880325623ee1009f0b9188a07495298"
SRC_URI[sha256sum] = "a2b737977d7282b207dea5eb61b22bafef5a2cf2dd89f9ca2046424de370ada7"
