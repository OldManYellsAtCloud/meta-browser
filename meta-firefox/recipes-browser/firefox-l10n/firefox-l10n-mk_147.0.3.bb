# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4b8acfab6c71bab38912f72092087d6"
SRC_URI[sha256sum] = "309e8935b66f74b6e31a0321743f9341b56c6cd6044a453a2d11afe1e8ad0f27"
