# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e41c0777905c177f0aa71e6bb9ff44c3"
SRC_URI[sha256sum] = "34d74f54f8de485aac2d6201c01205c3fde033384b420ad3bf32e4ff6f4dd54f"
