# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19dbd3082a7599fa138da0760ac1e2c1"
SRC_URI[sha256sum] = "28a569c0646496521eb2ce3e21d90e0f0af80afde99a3184d070095225fca4db"
