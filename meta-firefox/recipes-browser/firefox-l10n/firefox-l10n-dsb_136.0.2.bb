# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a79daae2be8bfb315e4a100f12560bf"
SRC_URI[sha256sum] = "67253028c3ee69b714be11caec4a273a13c9c187281089533e4778ec021bceca"
