# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd06709ec000b739dd7b68541670ba6c"
SRC_URI[sha256sum] = "edfb577da61a1ce198f4148da177dae2f9cd03233f4d2805d2cb93632393e2a7"
