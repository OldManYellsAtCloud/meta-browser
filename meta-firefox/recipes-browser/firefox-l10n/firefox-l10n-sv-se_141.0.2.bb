# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd80876b1081190da96877d7dbe60303"
SRC_URI[sha256sum] = "c33a64c78b77887d23fb8d7eda685df03e022079c2993f7c7a769584c82ad670"
