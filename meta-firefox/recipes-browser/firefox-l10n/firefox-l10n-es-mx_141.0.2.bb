# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abd0d6e4235596fa583f7e6dc8dead3b"
SRC_URI[sha256sum] = "17b055a9ab32b23c5ab46bc2b095f347c81983b0963c6fab56834f9cc2e08a42"
