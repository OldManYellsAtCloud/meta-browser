# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7c2bb6e23868aa8f11f9cb052d9db4fc7f465c5ee286b28415b949ee44d2f43a"
