# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c1377ef74da9103cbfda148bd6cf32eb35efd50d91f6216e9ad67cfba0636ff0"
