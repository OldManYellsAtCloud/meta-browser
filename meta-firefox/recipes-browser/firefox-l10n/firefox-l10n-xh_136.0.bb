# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5a298fabea9b44a7dff793e22c6852e"
SRC_URI[sha256sum] = "f8cb7db56b41408ec0f9024d1a5b3374507b1462c2a3e30f6eadfde987acedc8"
