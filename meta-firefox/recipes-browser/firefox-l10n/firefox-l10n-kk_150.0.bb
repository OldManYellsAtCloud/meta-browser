# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "781b88ed4b3621ab316509d6b061d561a55ff1ee94757a76458309e957d44c5f"
