# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0390d45b32c9a1b1eee44f640242f6e"
SRC_URI[sha256sum] = "b5eafd219ac26fbaf2732c95f291d8fd6171aefd330d319128e20c802f1cbb85"
