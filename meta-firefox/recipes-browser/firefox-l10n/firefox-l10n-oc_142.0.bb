# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fee869eb315583e77a566ac8a6dd04c"
SRC_URI[sha256sum] = "6c31bd21769aeb9fede1ab77548e4f7bf0822eb2776e25cbd9fa75d67996ad7e"
