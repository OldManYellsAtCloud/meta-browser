# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33b4bed1e8ab435cedf94d3e70e47efd"
SRC_URI[sha256sum] = "c18ce4a9ffc7bcaf05dcc3299951c51a914c777f2ec6a29dd70e4f8c307fb163"
