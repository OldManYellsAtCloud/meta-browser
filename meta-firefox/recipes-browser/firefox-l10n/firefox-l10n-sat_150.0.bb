# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "870416e6f0850acb79f5e5105b3da7e1e79af5ed747f36c45845aab7b448e77b"
