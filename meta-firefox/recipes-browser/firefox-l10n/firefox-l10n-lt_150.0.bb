# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e48155d7b12679da02eea0502302522ecde5b13e8d2334c99d03ffc881e38d3b"
