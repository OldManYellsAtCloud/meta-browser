# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4d8e757707d3c260c79bbfd3c460d93e4d87a19cbc6b85c482c337bc813d93e8"
