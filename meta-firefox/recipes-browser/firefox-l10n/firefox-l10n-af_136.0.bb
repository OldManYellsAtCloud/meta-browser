# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5f326a9d83c08b9b5f501c8a4f0f35e"
SRC_URI[sha256sum] = "9adbd71e11d2658eac738e28166f27e7dc0c0beae0f30c1d09b58b58948044ce"
