# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57fc740b64de1540b6a1b71330068334"
SRC_URI[sha256sum] = "3c0239ca38ed51849dcf5701b9f3b6389f12edacc1c55d12180299e3c9272862"
