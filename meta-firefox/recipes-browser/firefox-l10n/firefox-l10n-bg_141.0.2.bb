# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a536665bad88d2c8fd4c9ab70453dc57"
SRC_URI[sha256sum] = "3c00fb25c6b8fe2d2463f5d96b4faa3e50cdaf8e606ec681a00eb0637d9fc841"
