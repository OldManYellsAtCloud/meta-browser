# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ee034a2e178b051d9b57f91e5be5767"
SRC_URI[sha256sum] = "c2c32ad5abc10bc5595f7f5854493827065f3ad663fb7c844d78b25e92375275"
