# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0be51bcbf2a51d4a43f92aae8420a99a"
SRC_URI[sha256sum] = "eacfc38632178ac1175987748e4a193bcf2fd3768c6aa9f17875720e05ea2f07"
