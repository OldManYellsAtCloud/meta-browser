# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "908fac6a12fc984230f787e82774dae8"
SRC_URI[sha256sum] = "18ca5a9f2abc0bec2d47b814fe3234f9102a69d5ff36417c1c22fd4ff33be4f3"
