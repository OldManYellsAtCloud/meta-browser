# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9bcc1072ba8307ece244e0458a4ded0"
SRC_URI[sha256sum] = "435e1ba3ee02f3bf9af061b9d35d96d8fa5966985d7c82a7817eda81fbd30364"
