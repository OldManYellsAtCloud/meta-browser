# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7912ea2fce9be9e1772657cc725d2125cec4a882f6fb5d8cc0426f1e1a87ec2c"
