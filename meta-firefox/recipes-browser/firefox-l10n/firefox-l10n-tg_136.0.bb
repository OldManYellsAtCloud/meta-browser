# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a67d5871131cddaae7a66b29367944d"
SRC_URI[sha256sum] = "be43fa7041fda94e0c61342fd5ffb2a3794dfc15612cbcdb459de26c258a7278"
