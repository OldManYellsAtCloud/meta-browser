# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "14b2c7de4f1cf664bc1b8d11220fa1ca739e30116dd5d64a557ef4f904c5abf8"
