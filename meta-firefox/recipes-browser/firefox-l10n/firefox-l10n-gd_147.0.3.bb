# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90955c877d7e4a5342f367e9b7acbac4"
SRC_URI[sha256sum] = "0f02a51835b22d34cefc6a7e5c73d6e3161a937929eff686f986d224fb28b92a"
