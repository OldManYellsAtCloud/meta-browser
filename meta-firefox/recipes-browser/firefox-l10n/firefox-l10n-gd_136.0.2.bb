# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22be756f5547e960b98d2a8cedf689df"
SRC_URI[sha256sum] = "65954cb0c8a58aa7c07cdd416160efdf2544055529d88cc81d9898f4a0f55e30"
