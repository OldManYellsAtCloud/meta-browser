# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0f2d2fc52a9030a372a961c751f4c4ebf77f4fcfec924d7b7cc9ed703893d49f"
