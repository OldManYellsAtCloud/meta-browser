# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06bbb439055aabc8358721fcf0155766"
SRC_URI[sha256sum] = "dc73d97ce257d31de0bd19a20b665625ffab37dd124002b1a01dcf815f37eddb"
