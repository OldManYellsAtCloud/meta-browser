# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "28216f18a3cc6541447b51bf611e7cf884934d3a93bc5046e9447b0d5bef086e"
