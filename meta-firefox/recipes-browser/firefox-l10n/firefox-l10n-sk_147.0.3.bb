# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea867bd955b6e527b9ff3a586221f8ae"
SRC_URI[sha256sum] = "1d7f89c5d7ad92492a143d9b3d18e03f5b16b6e47bc077077f7b0634ca184903"
