# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b69304a08d781c0ccc572e8df4fd272e3efa23723f9d691c72bf0e8010becdae"
