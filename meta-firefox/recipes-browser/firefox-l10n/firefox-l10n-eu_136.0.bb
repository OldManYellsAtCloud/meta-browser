# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2c827cc2951d30f0071294e04503441"
SRC_URI[sha256sum] = "c6f66126548981edfd3f2053ea76ae985918e02a4d825772c8ded1914406577c"
