# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11e703a57c291cf5151a1ede94141030"
SRC_URI[sha256sum] = "f5ac6c29396a88c011f1925e0f70df9ec09bde294b91e4d2cd2bd4fb2980badf"
