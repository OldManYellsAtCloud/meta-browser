# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff90ab6ffc079ed8e01a2f35e9ff1649"
SRC_URI[sha256sum] = "f2a129e05261d73a60555e2874be6f634e9e27de7bf40f582f582b72767996aa"
