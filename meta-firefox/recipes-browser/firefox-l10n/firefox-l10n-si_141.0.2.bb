# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbcf92eb0cf05306940b8d200d13faf4"
SRC_URI[sha256sum] = "bcc59dcf402e9f3f9c8eaef63181c85b44c724b8697333011fd0b62e1b1bee3a"
