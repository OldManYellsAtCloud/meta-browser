# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b89f23d7265556e5b9832e779ebd887"
SRC_URI[sha256sum] = "cdb29f11377367805b1c139536e9e7b2dc4e2d13690adb548c01b70b49a55b0c"
