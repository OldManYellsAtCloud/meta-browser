# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3f2a4e8bdbf547d5160394b9c2f1c4a"
SRC_URI[sha256sum] = "668f8df96199e6b9c0b5933095373504e5071faddb891f3d6e4574e7e90d35cb"
