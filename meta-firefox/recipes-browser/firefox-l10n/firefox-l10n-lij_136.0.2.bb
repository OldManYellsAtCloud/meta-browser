# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "854dd77ed0e39fc70f5a87a089657df0"
SRC_URI[sha256sum] = "0760e62581dedfce65146586ec6fde931c8b3c08ce3b8e330376782041c91591"
