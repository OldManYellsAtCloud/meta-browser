# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "62cb4c4c172562e5ad12a2081d285bc5e2cacfdc91403d3bfd65442e02208115"
