# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c8d4dac2b8917ee41f13a6e9bd4ea5c1dc52f29aa1f28efbb88e57df6c40f068"
