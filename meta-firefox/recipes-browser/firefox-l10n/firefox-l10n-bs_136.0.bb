# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9eff3bd20757d21d7fb8cf32c997e41"
SRC_URI[sha256sum] = "6ad27ae376db9566b0023c5dfcc22cdc0ed1d66e91a1e27a8ad9c7cdb82c47e7"
