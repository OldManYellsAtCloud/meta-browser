# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "daf23093088abd1431fd79c84b5d9576de4b341f84fa0b2e1641a95f9b4c7963"
