# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02d6a5d533aa06e043a2dd7b045287bb"
SRC_URI[sha256sum] = "f1025f7caefaa67dc40fd5248a7692bbb6b3da71477bc3ba7565b46bc637228a"
