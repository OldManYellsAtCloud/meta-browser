# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3713bfd06e025e0f54d2601c512c4c95"
SRC_URI[sha256sum] = "b6419b665e62e6b3f7e17d832f758a421875d319a14b43812559a873f9535520"
