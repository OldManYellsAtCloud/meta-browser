# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb4f88aa7beceb12212cd648841379a7"
SRC_URI[sha256sum] = "5be48107a576ffdb999c6b9a9cc38742cffb144ffff20a634afa37ca3aeeb121"
