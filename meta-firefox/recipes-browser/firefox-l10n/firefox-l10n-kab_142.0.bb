# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8ca4fb04a668232220ea6343cea1e84"
SRC_URI[sha256sum] = "8f35c3d78ca0413a44133870cc9837d2b942dbc2a3b3a3f5e59c9a9db7952a61"
