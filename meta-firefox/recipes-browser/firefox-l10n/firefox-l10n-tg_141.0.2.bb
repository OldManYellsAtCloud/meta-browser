# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e390039c323a1a53db4d9be30877068"
SRC_URI[sha256sum] = "1292ae1f576eb97a15565d2c8e98194f8da4d4162d921d14fc2573ba055ef9b5"
