# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "807c2e5e10ee70405d08cdc5e3b3b749b9cec16b604e72b5fc4dde842dd0b076"
