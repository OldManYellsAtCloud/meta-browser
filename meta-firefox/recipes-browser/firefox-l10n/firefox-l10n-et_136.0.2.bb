# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c81c006a40db34b288a1ee25954c81e8"
SRC_URI[sha256sum] = "30ccd4e73b7e48597bea875e5c3edc45ab90c5790feb8368d9e277f71c8b20ff"
