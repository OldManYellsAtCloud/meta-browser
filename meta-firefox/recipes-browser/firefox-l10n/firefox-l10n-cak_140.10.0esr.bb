# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b505ed1109f8cd07d343b4b472ebb6bb65d4a012c63dd5ad8c33dc2eefd8ebe"
