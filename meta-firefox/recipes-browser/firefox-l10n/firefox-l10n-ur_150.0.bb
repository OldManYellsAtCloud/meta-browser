# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ddb3a3954ade41d032ef3427de348edc09fef306b38193258cf61e3e0ba940f8"
