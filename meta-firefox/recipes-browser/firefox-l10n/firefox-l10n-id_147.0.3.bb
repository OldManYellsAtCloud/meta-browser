# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0eb910780edfd160eebe950906563c05"
SRC_URI[sha256sum] = "78ff1581e38fd5c046d0816b817fad7155e22b1cd7b298185d4d35e3eb79bbe1"
