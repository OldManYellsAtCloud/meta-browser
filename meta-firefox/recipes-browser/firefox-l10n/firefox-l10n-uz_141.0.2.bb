# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d20e4bc3a50da756e71624b0e22cfff"
SRC_URI[sha256sum] = "391ae5220fa82b61f5f2c86562b2be7614cac6a2dc33a73f7f7d40ee373ac5c2"
