# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a89b703a1be4f631011374a52b543d1b"
SRC_URI[sha256sum] = "b181c1c232a4c36596f380d03396306e9de935b6a5ad1fa9b9c7de80dbe3f8fd"
