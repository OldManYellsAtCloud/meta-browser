# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7036b4a60bea79046812b0091dd83d4d"
SRC_URI[sha256sum] = "2f22231232ce6171202a89116a734428dd1f7e2c34a87e7bf184c9bb9cc670cb"
