# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "049489abe571216b596ab57235d7cb59091dcbf7884fc036ff3f16573b7c4398"
