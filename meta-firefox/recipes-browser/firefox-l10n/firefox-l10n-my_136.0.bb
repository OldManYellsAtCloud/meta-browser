# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "736a840c637370303c1e2ebaed671190"
SRC_URI[sha256sum] = "a2019c620c06ceb569513a11a29adee2f5469a7e1e4a31acc3b4c8b60def27af"
