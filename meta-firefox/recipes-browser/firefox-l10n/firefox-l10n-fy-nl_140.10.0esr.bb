# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ebd9181475ed867029a40d3d58c21a2975bcbab5e6d7e31dfbaf30298c4a9e2d"
