# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baa863aba7d733c64c64d747d66effbd"
SRC_URI[sha256sum] = "433a1571cdcd137d112fd976b45efadd21f2335f925d49d21f94b4d41dd7d3aa"
