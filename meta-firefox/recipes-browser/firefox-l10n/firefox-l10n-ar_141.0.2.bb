# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1efd94b0bdaca41649ecf79782bdd770"
SRC_URI[sha256sum] = "82ace9113d320fc9a31334b55c255cf64040b717bccba470dce5a44bee1f392e"
