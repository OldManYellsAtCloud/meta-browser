# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c8ed0cdb9d89230e4e1154c2ab240a7"
SRC_URI[sha256sum] = "3a806289ceeaa58758b4dfac3412ec1d4540cf3f682740fdbc139cb22c9c4c7d"
