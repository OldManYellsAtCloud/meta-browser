# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a7a1a85ff15105546d95f44837b0d91db091cc65a22199e93ee8002f607b0af2"
