# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5245bbb44419e05c6c7950bd07c51a52"
SRC_URI[sha256sum] = "8e3e63f470d3df732eefa84b8c1a7c4ae782bb60ac84302dba0b74e94bf7fdcf"
