# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0749a7241a3484e9ba4e5d97941ccc49"
SRC_URI[sha256sum] = "bdc8ceaee6718f36533ed761fbf6b427d1b0b4dfb5e3e0a52242b44732efe9a1"
