# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b774c9437238e8bdafe6744eeaf1b812"
SRC_URI[sha256sum] = "abdc3e6b94c3f3f3d4932de5161e0d30c15cb93822702994a1b9fcdd42801ba3"
