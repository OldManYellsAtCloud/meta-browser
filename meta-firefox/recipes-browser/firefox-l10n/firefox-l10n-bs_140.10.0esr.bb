# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d991897bc1c99f1896d8d33c993dd74232a59a8fae072bf33c647587930b87a2"
