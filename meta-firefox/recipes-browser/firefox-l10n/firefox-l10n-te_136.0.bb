# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "181f72b4e00b2a07c85efbc2fe50a770"
SRC_URI[sha256sum] = "5969790379f54d0be4ce76c284b2fae0fabb8a3b011e34a4b286edf51bcb8808"
