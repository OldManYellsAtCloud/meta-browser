# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b11d65101a74b79e641c483a267de028"
SRC_URI[sha256sum] = "878f985e8afb8f345f59a7bf484888bf97d98f2c0f996b4b02e7c6aede5b2cfe"
