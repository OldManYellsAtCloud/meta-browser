# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "962db69a2c973fb2e0df2306242273c1"
SRC_URI[sha256sum] = "9f22e18a2074cd1c173dec3ad0fd2226305e893d60afd5b39c93e6b77f219d41"
