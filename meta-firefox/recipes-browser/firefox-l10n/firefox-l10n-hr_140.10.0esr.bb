# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3c8d3eeba2a29110f1e096be0e6414d0c9aea28730f64e7d8783ef80f3493998"
