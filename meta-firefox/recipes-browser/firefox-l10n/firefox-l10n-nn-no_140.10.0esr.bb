# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "69a02352232752cef3cf64b84156bcbc8beabe6cf104f4f45a10bd10717fcd8f"
