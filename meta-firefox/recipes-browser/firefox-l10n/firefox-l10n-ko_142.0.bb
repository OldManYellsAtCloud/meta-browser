# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd7c342169dbba8d29b99c1eefc44237"
SRC_URI[sha256sum] = "0be72c60794ce146f747a86573445b10480fa186466cb5a8ce8f2fbd5f358595"
