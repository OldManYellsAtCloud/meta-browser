# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ff2774f509f85c6d38c5934398f6039"
SRC_URI[sha256sum] = "20e424b19b6a2852e18f34351fd352fe150add59ebac8987a0e3f75ed525c37e"
