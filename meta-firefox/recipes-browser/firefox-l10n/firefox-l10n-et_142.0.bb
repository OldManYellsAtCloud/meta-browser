# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd100c2c12047bddebcfc105a06376a8"
SRC_URI[sha256sum] = "a7c17510571563d676a9f56390a6a2181b20378aec383d5d0404d2f13ef4d77a"
