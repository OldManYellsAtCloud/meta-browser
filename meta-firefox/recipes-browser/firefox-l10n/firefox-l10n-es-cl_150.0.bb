# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b1380435db93ca34c6337310cb919c49099af219e67c5d3bad7858e4c917ecf0"
