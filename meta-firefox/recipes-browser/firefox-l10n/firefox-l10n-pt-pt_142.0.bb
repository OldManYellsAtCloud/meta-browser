# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14320b033f6a07572e57afc58bd09050"
SRC_URI[sha256sum] = "183c1133ed1ddfba9acd01ae2df7cfeccea362dac35314979a7de8f2c4ae9173"
