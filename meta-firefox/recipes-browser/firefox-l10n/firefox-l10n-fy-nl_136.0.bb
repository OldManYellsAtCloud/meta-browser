# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9405767d95bea16cc6b54661c8ca2b8f"
SRC_URI[sha256sum] = "b10bb13387dc41263c651c9ede5d0e4b03766255b47a17277ee92232806847d6"
