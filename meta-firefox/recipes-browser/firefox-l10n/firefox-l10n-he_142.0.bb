# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df2bb622138815970b79ae01bb0b0163"
SRC_URI[sha256sum] = "6f94b9c760ef184d6b1337e1f221400c44c85a250d0c89b6c8c65ccdc96f5adb"
