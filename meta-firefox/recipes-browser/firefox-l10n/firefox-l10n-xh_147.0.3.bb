# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f28f06201dd65733dd004ef169d218b"
SRC_URI[sha256sum] = "f54155643e5f409cf7f71c094919a35170365e5c4fd245294ee7e5e02612e388"
