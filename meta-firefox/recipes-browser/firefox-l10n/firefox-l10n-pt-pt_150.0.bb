# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4e8c024fefb4b1d8225abc0ea1dfa77de86997005cccd915ee5540b823b4c2fb"
