# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "17fe4ac5fb2052dc1ee3168908cc8859570ee574f4e2c395638c25ee11e93bc3"
