# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "574c2b0d7f4c054e94aa9a44459e9f90"
SRC_URI[sha256sum] = "fd00da9169e8965e44678365ac2383c57a6a398bacd01f51feea50032d89699d"
