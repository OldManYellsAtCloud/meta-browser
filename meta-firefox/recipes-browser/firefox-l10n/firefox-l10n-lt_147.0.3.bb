# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d2580e54200c93f09839637619e1cbc"
SRC_URI[sha256sum] = "1b2e9b3f3094354370820536454dd19851118cfd21904c23cd8912c986cc6bc4"
