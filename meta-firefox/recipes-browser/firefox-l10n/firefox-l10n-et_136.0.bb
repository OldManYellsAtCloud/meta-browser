# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f69504a6b2b9057425c522ac96440f0"
SRC_URI[sha256sum] = "d9075ea55fa10da2b4031ed0ccb13a5430d439f5b3b9c7ce409f73f301b2b9ef"
