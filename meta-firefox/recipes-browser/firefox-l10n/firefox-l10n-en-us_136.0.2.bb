# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eff8717031481e07682eacb065955cd6"
SRC_URI[sha256sum] = "57ed0185255c8b85a1b0f57757245b7e334ee526b23e567d3651d7a4e3318786"
