# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0892ad5700a297a9ab1ee7fd776418107f0424115ce04b58b4b3124ba26f59dd"
