# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf5c7451a128f302c24c5609b54d5d8b"
SRC_URI[sha256sum] = "4d0fe880e2de35b1ff5971158bb2c3769fdd202f85bf479538e25499a6ee0cbc"
