# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97fe9dc8761bb495077f7ed25615827f"
SRC_URI[sha256sum] = "25a1d210bf2eefe80e1acaa1e81accbc84da022beba110bc731ef33b2c4433fa"
