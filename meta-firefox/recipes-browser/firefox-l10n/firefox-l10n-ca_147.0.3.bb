# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3f18e19cf4d84fbd7172a3c810e16f"
SRC_URI[sha256sum] = "6a32c7b80b65dfb375ae8ef78071ca84a62473c548d0fef8cf72dcdb065eed4e"
