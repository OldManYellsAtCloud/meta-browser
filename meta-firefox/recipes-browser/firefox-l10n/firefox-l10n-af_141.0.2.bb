# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d116e894d3f02f4d0278e0978ee36446"
SRC_URI[sha256sum] = "ef00bed5ae894bfa0ef8ff3360382bdc5219f789def0aa52ca2578aff63c2990"
