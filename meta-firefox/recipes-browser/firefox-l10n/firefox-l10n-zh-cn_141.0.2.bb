# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29d5891525ef5041e716e9e9cd75756f"
SRC_URI[sha256sum] = "a29a3d67d173e476d38d90280c82cbee0be4bb9f1c4b25a2fe20b4332e1dc1e3"
