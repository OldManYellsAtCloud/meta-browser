# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee0008a906e40ac08cea0243927e73b1"
SRC_URI[sha256sum] = "4f8267e4780ff7db8726e8db763eee4fa6cbf1a8bb12c60dee0add36b57dda79"
