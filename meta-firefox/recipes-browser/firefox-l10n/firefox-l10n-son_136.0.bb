# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1311780654e6a5fedb79e4b8a5e2aa24"
SRC_URI[sha256sum] = "af08b49cec152bf3e3743f8fb9184ac5dcd72d85e51f618aefcc819cafeff179"
