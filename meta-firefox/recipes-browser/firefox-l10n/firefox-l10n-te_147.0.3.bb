# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63c79c49a11924c66ee9fa0168fe7b09"
SRC_URI[sha256sum] = "5da6dfc4f9ff7e15e2fcfefe12f9552ee2db189f3ad66ff9937a17860c30c2e8"
