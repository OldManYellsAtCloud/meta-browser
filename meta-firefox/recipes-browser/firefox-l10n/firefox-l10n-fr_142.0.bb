# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f47b33116c59111417757ab6ca45a039"
SRC_URI[sha256sum] = "79ac0d3304da88e0d5483a63c2159b74fd7f1afc1a864edec6138031d89b814c"
