# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "00cd52b9e5eabf4219f668215e47734caada4c373ddfa10d100e1bce326a6849"
