# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a695ee9434d25daf2713a082bd978add"
SRC_URI[sha256sum] = "1cb1b2716f503c4fa4105020d814d9cbd9a89efe0a0f9111c66285c4eef13f25"
