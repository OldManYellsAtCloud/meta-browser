# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68af9a832f005f3dbe7d7e5a1d93d48a"
SRC_URI[sha256sum] = "ec2f9889011dae903230a5b717bbda448f33c212a3cb2a0b4c142c051cba99f8"
