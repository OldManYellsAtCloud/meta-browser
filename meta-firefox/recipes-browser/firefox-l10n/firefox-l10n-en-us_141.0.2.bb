# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58d041047ccf6ece2c967dff2edd5194"
SRC_URI[sha256sum] = "68e44aa72d8f8ea928a8b7e15f81891dcc022aadf6081997770b3ede72c1229d"
