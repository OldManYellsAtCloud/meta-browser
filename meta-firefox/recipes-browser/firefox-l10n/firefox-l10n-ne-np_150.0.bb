# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3453f9a0cbbb3d61cd5c0be561518280daaa37895154a2cca715642d747bd24e"
