# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54d0b9f810528aeceeffb15184deb5cb"
SRC_URI[sha256sum] = "261531f8aab947fe52284d458aa652e2c6571eaea7e19f3bb9798ecf54936694"
