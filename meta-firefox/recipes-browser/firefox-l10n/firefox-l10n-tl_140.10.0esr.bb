# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ed963b8e3302bd082dc2ca3c872b17cef0ca0eff9ab5c30e37fb53dc38dfeccd"
