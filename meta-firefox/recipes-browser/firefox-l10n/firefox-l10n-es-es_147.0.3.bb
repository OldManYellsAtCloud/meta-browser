# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2002c9006bf3b9ecff8d45d20cea2e7"
SRC_URI[sha256sum] = "a21149f37735a81e7a0e854c132649037628a6abf0b540013ff45e0ac945c44e"
