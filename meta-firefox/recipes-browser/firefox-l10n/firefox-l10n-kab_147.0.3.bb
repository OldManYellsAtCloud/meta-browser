# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd900dd95493e986f283574a8374420"
SRC_URI[sha256sum] = "934d831935e9736e4151ffccbddd4ea326b798dc015089b329094445f1d399ad"
