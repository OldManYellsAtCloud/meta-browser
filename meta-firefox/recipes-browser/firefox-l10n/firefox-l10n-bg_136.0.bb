# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d3bbdae1086c3fb732216ade8ab3b2f"
SRC_URI[sha256sum] = "a6f6f0a904a1012dfc673c4d78cb93e305f1a65267465cb88fef712e34f90224"
