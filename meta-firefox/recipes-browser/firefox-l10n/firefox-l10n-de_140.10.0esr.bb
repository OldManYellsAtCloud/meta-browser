# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fb27bed25357ca12c3e1d86549fbc5dee4bd8e5e07c1cd912e85bd8a7f27e7bd"
