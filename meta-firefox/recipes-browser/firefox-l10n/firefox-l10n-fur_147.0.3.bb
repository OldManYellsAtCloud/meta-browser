# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14f17d53ba4cfd0a9b3485549e3502a9"
SRC_URI[sha256sum] = "51fe6f8fae7667a723397109252e9c041789d4f2557e7dbb696a977bfe8c97d3"
