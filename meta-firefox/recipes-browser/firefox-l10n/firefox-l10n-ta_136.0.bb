# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df3ec2f567f086ad17c1e945764b9dab"
SRC_URI[sha256sum] = "f974a068052b3f241380c0fcaed2ce33ddf5ac3076502db6487014ef4929bfc0"
