# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd55f1e8c0122f36b2608fa737dbe816"
SRC_URI[sha256sum] = "5b9f040f6da6755147d5d58c0291163eced8b7cfd77aeb6688f9c9c7d01a57f9"
