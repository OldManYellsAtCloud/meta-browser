# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90c78eac0ac2f6bdd8fd7e5005a29bf5"
SRC_URI[sha256sum] = "61517c8d4dd9cacdc52ec659005a0e5779cd74432fe6288e1496de12de30d0f5"
