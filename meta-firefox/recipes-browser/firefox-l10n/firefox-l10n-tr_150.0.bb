# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7a9ba846baa10fefd3b084618eee30ed03e520b6d15b73643ef3e86133822c44"
