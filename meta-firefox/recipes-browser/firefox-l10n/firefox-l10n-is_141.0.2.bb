# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f4f62bbffe066973f64bb864c272340"
SRC_URI[sha256sum] = "1d531512402c0e6f24df8b649e2b772e55f73d2b4bb860c654520744b5ab2376"
