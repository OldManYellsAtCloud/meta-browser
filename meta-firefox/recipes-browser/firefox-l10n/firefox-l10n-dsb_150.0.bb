# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f29a7fe08af42fa0a6f965c4f85b90de759c78ec22d2c08fb8d02e7a13dff86e"
