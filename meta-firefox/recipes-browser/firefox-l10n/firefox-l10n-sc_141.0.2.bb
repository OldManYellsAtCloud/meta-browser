# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95322246f2c958136b22c384fb957e8c"
SRC_URI[sha256sum] = "96255b1ebd7f97857f3ba97e9bdb06e464efb46eea43ba37e43167561f0f5298"
