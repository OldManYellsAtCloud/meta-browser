# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95efc37bf523e7a1f1100be8945e6ee2"
SRC_URI[sha256sum] = "2586fa7b116e79ba3b6fcfa9b698301afbbc6d9bfe76d596eabdf1d8556df241"
