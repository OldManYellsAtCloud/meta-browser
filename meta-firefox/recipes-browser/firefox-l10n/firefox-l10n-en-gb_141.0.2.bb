# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "442c490e168f3a0cc97f48ef5a39d9bb"
SRC_URI[sha256sum] = "af013ae7063aee77d3406d89e0d11199d3622cd1d4333dd5e3575f2201f29143"
