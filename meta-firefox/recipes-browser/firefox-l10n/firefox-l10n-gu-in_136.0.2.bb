# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25b91891a106aa3959e81729601bb5bc"
SRC_URI[sha256sum] = "233575765bcc61dcd0194c984eaa54d7bd8d6a96a60bf9ad1ae5fc25580ed355"
