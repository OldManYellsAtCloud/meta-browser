# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ec5f610f7b5f8685d324a13bf26ec9762beb5cb7b2eb41704f7e4f8069f60a4f"
