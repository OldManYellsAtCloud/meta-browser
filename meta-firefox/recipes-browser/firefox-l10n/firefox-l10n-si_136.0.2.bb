# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5971c230d938c2d87160c6fa506a1272"
SRC_URI[sha256sum] = "a8e5990691a46ddb1ab2b65472e497f33e1b46b245ee739aae09a4d5491e0dc6"
