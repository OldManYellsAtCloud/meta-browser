# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9025d31275b0d47b463a7abdc440bcba706f95322a7746cfdaa5594f22d4fdf4"
