# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fcdfdb64fe4e617f7e753bfa7492a4aac9bc9497deab1348d129c5db825dfd1a"
