# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "395dd61bee1c5fde32417af910f4467c"
SRC_URI[sha256sum] = "ec532cb34d7c23f16c9ae6d969d73d1a40b1daef35da19ee276f77e434faad96"
