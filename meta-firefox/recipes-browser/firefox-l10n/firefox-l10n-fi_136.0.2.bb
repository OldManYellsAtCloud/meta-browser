# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5be5fccf470d2683e1fe25f22c284687"
SRC_URI[sha256sum] = "384038c77735317b2e5d25e8dbdac0a7a438cc661305a8003a240c457c9cd396"
