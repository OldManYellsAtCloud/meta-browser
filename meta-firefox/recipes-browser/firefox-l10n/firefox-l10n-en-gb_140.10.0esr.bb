# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5dfc3b581829588f26602c20a9599844f96a48309f9d603ade47305bc36ba331"
