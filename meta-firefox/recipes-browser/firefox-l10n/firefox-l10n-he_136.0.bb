# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "168a9f45f1193fdee87019bce4f81caf"
SRC_URI[sha256sum] = "3e3d4209f568683ac30ce00e205ddb52095b140ef9a9de09cc1fa41c630631fe"
