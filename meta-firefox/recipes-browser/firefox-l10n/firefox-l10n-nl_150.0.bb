# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0a4867bd4b2490631534feb018651f19aff8c00f0002050a1fe8578cf6793bd3"
