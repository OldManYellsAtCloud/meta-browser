# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc88f146030cfaad5927705c90a131da"
SRC_URI[sha256sum] = "66a3617a1c596aef4dd1a8c872bf8b7f1beb8cb79b8f9c193e568d7a7d821cbb"
