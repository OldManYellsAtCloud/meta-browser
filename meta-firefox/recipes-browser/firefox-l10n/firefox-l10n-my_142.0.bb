# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c4e4afecc8c520f204150958581175c"
SRC_URI[sha256sum] = "bb55cf3ab5e47a88ff01386e4c30fb9895ead63126b770de8221b318a1829655"
