# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b38f5cd8e916a039a1b8e0b843db03d"
SRC_URI[sha256sum] = "56a2b6fba5beddfd465f2f0d6174e57d1d040c7b0d7fc81b2e084dbc81159690"
