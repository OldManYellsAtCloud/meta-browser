# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c52fe44539bbfd49d5f75129a24e991b"
SRC_URI[sha256sum] = "f5154acaef38a4a5b16853e14e8e59c2b2f36978cd54186e2c4a55112f38d8f5"
