# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "970b45044e6f2410413ddd390b56bc4f"
SRC_URI[sha256sum] = "efd1a2272e0e5ffc475fd076501636bd6de2ce27bf5b2e2994d55c7950f07b07"
