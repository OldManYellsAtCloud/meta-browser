# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "38129682b724c9959f114cf6c58354c277b44d1dac933f3edf04a069c1c4cef2"
