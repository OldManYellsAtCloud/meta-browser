# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d2cf364d92420a536dfe03ed445a6f09baafe89879fdab0b5110e0443695fda8"
