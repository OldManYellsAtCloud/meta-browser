# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "773f0807179d9975d969f0f52518d164"
SRC_URI[sha256sum] = "4ec0e3bc4f2d08d1550f5a9012d9f92c4b63e3a10e6ce1de4cafb1368e2b5904"
