# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83e8e4dbff797058c4803a3c2b1581e6"
SRC_URI[sha256sum] = "319195cd2135d44bc064107a5b94076d1cd49d00e9a9af3624f86d67c0f63bf7"
