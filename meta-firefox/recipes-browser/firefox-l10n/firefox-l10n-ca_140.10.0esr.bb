# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8048d896d70521fc976099597ad9f0af75102ff98312ac37fa93acd751157ae8"
