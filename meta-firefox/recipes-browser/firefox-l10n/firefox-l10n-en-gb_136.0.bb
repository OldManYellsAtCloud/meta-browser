# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce9461ab24e7907867291a68b09cbc6e"
SRC_URI[sha256sum] = "586daf762f4e99f31719825a12a41267bf6bd6a7f5d45a9c3a4b60f7d30d41d7"
