# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8c8ffefac57c54b02ce6842b9ba164de25ef47b4d3b5edff1d3079d0278cc8e3"
