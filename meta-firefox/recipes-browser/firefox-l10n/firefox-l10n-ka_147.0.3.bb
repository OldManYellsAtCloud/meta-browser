# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "123dd4b930e46c904dbde5bf13ae96e5"
SRC_URI[sha256sum] = "33ac2704505aafdff56f575ae139b06e0df746e88e73abe76216763268b454c8"
