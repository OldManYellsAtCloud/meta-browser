# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30fc8c14a049eb9a8f244b9ec8a57ef8"
SRC_URI[sha256sum] = "93bdb3471a1d1a43094dc25455338601f87d2227db2e9261937b6d22b593eef9"
