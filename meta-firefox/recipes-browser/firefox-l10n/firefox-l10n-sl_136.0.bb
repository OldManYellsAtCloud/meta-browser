# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c33623b75631f183eba3fd4d97a4461b"
SRC_URI[sha256sum] = "78ca38357d9399b1495f4392102ff410b8e8f348f9b880acd801746f34dbede6"
