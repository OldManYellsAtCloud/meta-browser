# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9cf7d2d2a171809eda2e3ca479535857758ca701dac05229bc719846d9b13f6c"
