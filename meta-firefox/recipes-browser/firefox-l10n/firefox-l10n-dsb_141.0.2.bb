# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40ffa6ee8d06b41496f358a10b97f154"
SRC_URI[sha256sum] = "4a0c75de3242749c4c47d519b92410df724a1b675cc8df1981a824197253f511"
