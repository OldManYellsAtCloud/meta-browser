# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbea254c0b132db702fb786a8b0ed038"
SRC_URI[sha256sum] = "2e8d982f478435be7767e95babb3f017f28bc7587fb51853d36d619416bd0868"
