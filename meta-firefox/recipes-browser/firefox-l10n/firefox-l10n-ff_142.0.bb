# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd2c949d11f31caa77cd31d38730091a"
SRC_URI[sha256sum] = "62e823c52441fa4224610a9a62b996ce2a784bb42af3ef5be227c8b8eb426f92"
