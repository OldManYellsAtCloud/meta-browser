# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32a15a4842e51e320bb9e18a39c6c2a2"
SRC_URI[sha256sum] = "63cd8c29a4c405446ed6fdcbb0f6d2577130ebc93fba6f3896d6d228e6d72d1f"
