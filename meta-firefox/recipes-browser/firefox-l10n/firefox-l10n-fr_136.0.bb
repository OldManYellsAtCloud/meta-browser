# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1857662b3ccf0887a3d0967dc7799c1b"
SRC_URI[sha256sum] = "953c7e08dce3963bdfadccb14ad11f4439770f3463b8a306df081bd3e9cc3405"
