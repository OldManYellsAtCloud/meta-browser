# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b54fecc696f451d6f9fbaf1bdf9e1f96"
SRC_URI[sha256sum] = "27110a4ddef8072caa69f676b545c9caab9c164a62136d7f373c9de549d9d8a6"
