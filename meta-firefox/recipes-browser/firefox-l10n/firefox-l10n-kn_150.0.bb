# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5eaa6afd82985dbe6f433324a71ab8e5d647ef91eff1dec9da5e13fc0c6b284d"
