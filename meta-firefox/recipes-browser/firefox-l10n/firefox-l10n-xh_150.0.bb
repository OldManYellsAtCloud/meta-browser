# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fdae898782f907efdef0a7905c6ab9b5876681f6c45ce9a52ab131dea7d6d1dd"
