# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2095369261d230527667498a213bc2f0"
SRC_URI[sha256sum] = "f66cc9a1e185122a211e437335cdadec0b3f4309be570c9e447c9477903469d4"
