# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "745d5110983a68706683457f8d6a5b1e"
SRC_URI[sha256sum] = "b5e075d55d1fd8140f0cf149f72dd46b96af59acca4f45194ff4d12490df8532"
