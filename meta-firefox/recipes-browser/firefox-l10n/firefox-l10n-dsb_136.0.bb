# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f259ba625533067524158334b1a94437"
SRC_URI[sha256sum] = "e0e17db43088a01b546a97da649392919b16af290547dcf22b492939a99f9405"
