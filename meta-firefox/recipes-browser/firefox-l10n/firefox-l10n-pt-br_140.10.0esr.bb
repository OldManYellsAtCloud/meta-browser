# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "036b119330bbab3d91721f0a0c4393ebb6f05dddb5ab70b344e6deaa8e337714"
