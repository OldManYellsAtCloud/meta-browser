# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3466356e8c2966283395883225478c66"
SRC_URI[sha256sum] = "bb677f71f4113ac596a558161385dcfa52f152b0c81b1262d2c22478567627d8"
