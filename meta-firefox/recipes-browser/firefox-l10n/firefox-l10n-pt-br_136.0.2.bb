# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36a2b91576ad397379aaebc9628dcb04"
SRC_URI[sha256sum] = "251011513599390381949eb387e0d56e0202cff185bfa2e72d6a3fdb072c3742"
