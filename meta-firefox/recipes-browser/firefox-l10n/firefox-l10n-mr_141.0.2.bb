# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a5f5bde6628e54def2aaf308d28e2a4"
SRC_URI[sha256sum] = "51e530321c05937ce8c5a37d79a7861ee7eb1c2ffc5d71f8769c124b813a1d6c"
