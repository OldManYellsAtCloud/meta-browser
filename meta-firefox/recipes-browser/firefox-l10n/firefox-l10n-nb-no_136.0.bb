# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3b0f3157702e0db1ab69aeacab50c4"
SRC_URI[sha256sum] = "4b2a30989cc9fe8db90b4654d6d89d85789f256fdb9e3f0ca446a62c7d475daf"
