# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c783e448db167d9bf8741c0c7bc7aa5e4813fb3cde9e8112df7513e8c74d2b76"
