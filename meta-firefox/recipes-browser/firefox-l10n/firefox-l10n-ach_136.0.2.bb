# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bf63e72c8829b98c107c5d23644e952"
SRC_URI[sha256sum] = "40918dd9ec3b2fa9fd27b00d2fe57978630968bec2f4dc4d07a5ba3c53981981"
