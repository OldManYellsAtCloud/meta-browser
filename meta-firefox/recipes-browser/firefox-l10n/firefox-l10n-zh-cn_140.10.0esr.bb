# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7c6982551b50d6043ff460e07f74e525e0f8b2a3fa905f80f3b20dbf271d65a2"
