# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c52f508ffd42cccb9681ad46731d068ea7e3729991f926873c93ff8c77554f1d"
