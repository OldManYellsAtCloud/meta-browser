# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1996ff82e4c03f729eb940e093c9420f"
SRC_URI[sha256sum] = "1ce600a59c590b14a416c91896878bac705c0b16f512638fa68dba157c36f671"
