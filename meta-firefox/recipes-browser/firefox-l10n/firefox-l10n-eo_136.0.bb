# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b44d2ed1aab91bf515614f3f1ca8b294"
SRC_URI[sha256sum] = "a5c6168720dd9435523827f7ec28965eb3c169ad1d8fdbed09efed5c372fb1b4"
