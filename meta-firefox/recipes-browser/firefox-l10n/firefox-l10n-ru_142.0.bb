# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a4294a802cb01289fcd0dbee213f7f9"
SRC_URI[sha256sum] = "4a7c48c8ab579487c9e412069a58de2aceaa4e5fb21f754725addc4e8d035f76"
