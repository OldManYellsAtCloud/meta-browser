# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e68efd7dc65ddb3fbf4d7bec3ee43ddb"
SRC_URI[sha256sum] = "ea5989d0c744daf231b6d2a0a2fd33247f25532a6b8d876c63caa56202339101"
