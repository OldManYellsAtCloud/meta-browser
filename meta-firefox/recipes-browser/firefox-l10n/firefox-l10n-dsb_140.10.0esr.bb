# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "51d51e4f31acbde1667ee38b0133fd98eb916b50c1217614d629fb69c356b64c"
