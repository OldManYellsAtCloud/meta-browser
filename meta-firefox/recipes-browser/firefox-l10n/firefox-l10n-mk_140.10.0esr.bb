# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e4fd64e5ecdaeed1dc684f4bfd856fbf665ff3ee0f2164ca171e01e808e4e9c6"
