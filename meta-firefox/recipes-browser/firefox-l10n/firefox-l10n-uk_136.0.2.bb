# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61ef2582eb5d118641dcda19031158de"
SRC_URI[sha256sum] = "5b3b0952ca3e700c19719e3737cf32f34cd3c2d87dfbadd4b79668068f2e7fec"
