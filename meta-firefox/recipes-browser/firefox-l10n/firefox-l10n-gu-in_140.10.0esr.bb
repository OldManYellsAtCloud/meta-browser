# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7720648cab31277ac63edbf6b8349cf1f0d1f3709b0dc842fee2e7ccb7e60326"
