# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "21a626c50cc066e1b5190c82aaa4e199df4ecaaaba27eaef89dd770cb65b146d"
