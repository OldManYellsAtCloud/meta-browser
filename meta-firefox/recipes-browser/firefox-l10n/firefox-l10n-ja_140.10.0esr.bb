# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "57747d145b9b7ddb819581d4bc7acf5f0f892a4618e2dbb3fb118810da115173"
