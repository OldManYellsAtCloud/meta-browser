# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec7f8618955b15f0321ac6392022f393"
SRC_URI[sha256sum] = "b868c470b329ad6734d1862ab14973e14c3bf03ca3df6753bb496f1ffb1af119"
