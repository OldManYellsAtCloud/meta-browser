# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d46af5af34da48ada14239ae9199562"
SRC_URI[sha256sum] = "8cd19dc3962a30dcdcfb8a3b0997a0bb7299ceccc1036808c1aa84602f3fb2e1"
