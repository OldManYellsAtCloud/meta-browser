# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c9b448ec9c39af6e7e77bfd74b1d0bd"
SRC_URI[sha256sum] = "593184d19afe75b649fc236cb2d79e98752e7fe06daba4a1fe1bdbfa72609177"
