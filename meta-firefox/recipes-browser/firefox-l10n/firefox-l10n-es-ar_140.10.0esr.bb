# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8a37fbbf7f68bdb4edd2a4169002eb887a91363659f5f98912c33f3adeadc794"
