# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3cae5f40f3d6abad491071d47b6b3b0"
SRC_URI[sha256sum] = "50ad05122d5734c09e96f5725f9b1c3c6e943aaab5e0a6583bb82b7add4b695c"
