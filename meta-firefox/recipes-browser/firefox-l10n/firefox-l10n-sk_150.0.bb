# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9a1037b02dfd0a24bcc40d6d7532310813ba240ff287df6a45f74bf3a59e72d3"
