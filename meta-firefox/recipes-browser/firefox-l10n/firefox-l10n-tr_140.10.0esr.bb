# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ec2a9b358a3f018540d670db5a97db4adc3455de1055cdd31632c1441d1c2aa3"
