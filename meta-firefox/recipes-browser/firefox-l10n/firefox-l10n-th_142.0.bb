# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bffa34377f1338eefb41f485377ab40"
SRC_URI[sha256sum] = "4e91410aa3b036e6c1fd120e2e39cf522ce222638c1235eb463eb2dca2a7de45"
