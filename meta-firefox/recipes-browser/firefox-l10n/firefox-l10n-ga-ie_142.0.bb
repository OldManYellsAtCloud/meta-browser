# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb35dc462f1f12c57bdd2224f584ebc9"
SRC_URI[sha256sum] = "311e4dfe3aede20d1140bf56bf64ab23d4684391710f53a8f7393f43f9c47f1c"
