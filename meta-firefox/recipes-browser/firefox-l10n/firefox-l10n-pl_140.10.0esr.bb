# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bf225b39e4696f2fb0cba9b489fdd03ab43f602a7c7dfc0c257a32a8d8253c37"
