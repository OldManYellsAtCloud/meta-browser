# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "60372a78e572cd818ba913355f3abeba6f3496184a99d3a744f5c0d1483e951e"
