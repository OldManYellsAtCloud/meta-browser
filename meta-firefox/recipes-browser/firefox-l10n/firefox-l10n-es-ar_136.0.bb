# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad6f0f1ce2ec2229b1978c4924eae7b0"
SRC_URI[sha256sum] = "28035c1183cbc21dbf788d995dfe24c4a4e2248ee3499ea88e6bbeed2b32bd78"
