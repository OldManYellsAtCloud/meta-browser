# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8f12c774c0d4bed2d39421ee2849f80"
SRC_URI[sha256sum] = "3dd796ccd4d2c3b5d6d9690b13d39370aed6d8ce5aaf0e8b719c765f225b36d4"
