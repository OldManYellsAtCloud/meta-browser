# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6ee5af654dc6bd8cc817b0bf57068de9ff0a675e3e2312e2d91e56ee02cdc8b8"
