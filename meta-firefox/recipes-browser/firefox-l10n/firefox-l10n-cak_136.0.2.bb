# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c433804f82cd7a8c4c3f6cc19d4d7f55"
SRC_URI[sha256sum] = "2e54f370800f68b8288bb35fcbbee7a595780d895d07cc638448fb646e3bc167"
