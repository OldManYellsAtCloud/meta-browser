# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b7d67ed2c49d44e31a4f4196a01518f"
SRC_URI[sha256sum] = "d3d2f40ee22f3bcdd6cecb73663c41f418776d06ba219d4aa801d90bd3a8d89b"
