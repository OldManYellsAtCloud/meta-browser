# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "31e1f8705e3881f03976a5f8c5b6150506b93fc20212e553945638800aa1a482"
