# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eab34d55eae59e54e3b676531bd5d58a"
SRC_URI[sha256sum] = "d962e0b1fb50e88c7e169a7de95da0c520ddfa8571368a9ddb9bd837a971f684"
