# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da8dbbcac6fa39d844cd572a434652d9"
SRC_URI[sha256sum] = "3496b00a263d09469c9fcef1894c074ddf1b694e2568907794143eb12f0b472d"
