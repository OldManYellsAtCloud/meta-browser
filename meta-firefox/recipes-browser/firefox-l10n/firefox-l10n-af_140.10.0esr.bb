# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ccefa979ba2d5c6a5d0c2e440afac0c4b6c4331cd9387c65dda7b2554f7b9161"
