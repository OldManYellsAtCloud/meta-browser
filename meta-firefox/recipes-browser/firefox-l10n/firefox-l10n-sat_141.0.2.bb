# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f77d575c37cfb7b23bfcbad5ca045bb"
SRC_URI[sha256sum] = "f6b05fb418805ca18d274bc863176c578546b42182c7fb134e89f9195603827d"
