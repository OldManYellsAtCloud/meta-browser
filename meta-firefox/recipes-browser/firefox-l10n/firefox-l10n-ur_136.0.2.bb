# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0827b58548c5616ec3f6b444012c2493"
SRC_URI[sha256sum] = "5492ad59ff71716df49d6945a80df41ff45f3f4b986847b2e7d717597bf99c1f"
