# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4819db54b27ec3226dca69ad7aa4c00"
SRC_URI[sha256sum] = "e7bae94b6515d4fe555e7b60f9d1bd286eea07dd32eebb20db738eb952c0a6f8"
