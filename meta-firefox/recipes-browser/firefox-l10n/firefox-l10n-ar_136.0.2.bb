# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbe7cd520f2e6b5be5b1db245aed17c2"
SRC_URI[sha256sum] = "225d34f0cffcf89d46b68b4bec4c5621b856d158b35f173eaa0ed4c9da5f9104"
