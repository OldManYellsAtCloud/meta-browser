# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4cf24ebfa025f23c3cbd2cc6681910d484a8f8ef8799f3d803ab421cdced9b7c"
