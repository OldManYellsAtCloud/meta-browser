# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45faa3d5330c03565f275e1b50995266"
SRC_URI[sha256sum] = "d799e4964141e7519eb901ba470f5558cf3ca12b2e9b672d49edc3b1afd20a12"
