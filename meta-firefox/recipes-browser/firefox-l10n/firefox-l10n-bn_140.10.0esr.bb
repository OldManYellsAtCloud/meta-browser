# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4d86567beb0c6c73688b33bf11080102604c594852d285f1296e98dd378e43d3"
