# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eec1407d741b4b29a64aa31ed9667cdb8bae67f1f7a2290efd596ee3427ef598"
