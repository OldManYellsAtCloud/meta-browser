# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ebbb3fa3e11afeb8c2cb378e594845667e9d5bd67a6d50c0d1cd5fe8ffb57358"
