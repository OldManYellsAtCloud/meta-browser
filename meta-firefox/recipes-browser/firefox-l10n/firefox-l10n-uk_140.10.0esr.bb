# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3d64776f31a59c8418f2696f60d94957732107144777370a0e700c0563dd2ffc"
