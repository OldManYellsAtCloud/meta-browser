# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4c0e4c81562f6c876eba5de12d909ebf5336755a1d255b644b5337a78d057c93"
