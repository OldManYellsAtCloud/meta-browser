# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e66ac7220ab053a4181231d824739d5"
SRC_URI[sha256sum] = "6405acc91e062e36679d2e4946d656a68bd66f6d1fcae665414e8012cbc006f5"
