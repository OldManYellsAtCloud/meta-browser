# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50a9e86c9bf60ea233217372408d27f2"
SRC_URI[sha256sum] = "faffc864f71676f5ea459c991a799d04cfe9b375aaec7adce91b4fa57df41c0f"
