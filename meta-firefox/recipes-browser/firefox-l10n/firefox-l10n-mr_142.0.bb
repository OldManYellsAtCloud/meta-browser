# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30ed43cb8188f5945abe09adf0874953"
SRC_URI[sha256sum] = "6ddc21fb3f81f0aee1db0a5103987e13c89f93e8c482da15951836e0ac367b6d"
