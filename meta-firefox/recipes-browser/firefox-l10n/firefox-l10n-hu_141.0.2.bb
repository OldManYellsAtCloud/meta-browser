# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d5fea2002c9b8ea69d7b8254b2d7e49"
SRC_URI[sha256sum] = "57c179689c019f1962e3aad575645e1d0dbec3f4f1bfa1d20db87b1b5483ed7f"
