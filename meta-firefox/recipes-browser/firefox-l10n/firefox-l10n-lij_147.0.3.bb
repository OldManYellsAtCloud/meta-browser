# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c8331c445b1f5c7d062325bc33d3c83"
SRC_URI[sha256sum] = "adde7b73c7da1882dd4faf1807b6ab0407a1d71298e962d80807aa62ec32c3fe"
