# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8172aef63734c56f45bf0607caea925ad06febbabb908235e2953e5f31caaf72"
