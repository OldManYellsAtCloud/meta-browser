# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1518d15ccadb558b0a5a70f5f2c5bc30"
SRC_URI[sha256sum] = "57c865d0d8c7e1375b4004955538ee8332fc74c88694f9a5544a1921300630c8"
