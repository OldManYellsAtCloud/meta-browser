# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "506cdcf7ec706fa1af399648aacbbce2"
SRC_URI[sha256sum] = "052f6077ac9fd1a445844fd6598b8a069fc18e42f12dbe8ea3c0f445b151778c"
