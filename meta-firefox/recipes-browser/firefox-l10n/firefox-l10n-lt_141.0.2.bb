# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4a4c07ebea0d37ad520c0daa4700ccb"
SRC_URI[sha256sum] = "6ac3ceb5931fdc4209886642f12a5b35dae6b4596f00f1b9179b15dc6e73012d"
