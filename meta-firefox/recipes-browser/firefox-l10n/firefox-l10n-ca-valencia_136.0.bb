# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a22ed185aab0478666321ab86d5d993"
SRC_URI[sha256sum] = "d2cdeaa7972103622ef5fc66db31ce022e01c94e554b43b4c3d9d2d469795e82"
