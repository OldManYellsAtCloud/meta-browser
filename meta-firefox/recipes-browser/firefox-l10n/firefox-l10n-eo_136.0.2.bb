# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f4d3ebc8ea97b27c578fc2cdf576674"
SRC_URI[sha256sum] = "3b47b59327740cf85542c8af982ae1919d34ff888b90d3cdd374e153c0afe2bf"
