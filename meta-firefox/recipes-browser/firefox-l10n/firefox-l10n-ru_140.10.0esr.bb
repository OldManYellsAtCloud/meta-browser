# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2787bdc02a53f246f972086ac0f99bb44c9e09dbe85380ace809c3607f25f2be"
