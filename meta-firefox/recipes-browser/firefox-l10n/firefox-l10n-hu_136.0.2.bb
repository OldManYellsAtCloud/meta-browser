# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "464869a4c911265e7baa1a4f57795ebb"
SRC_URI[sha256sum] = "42bc09878770c823cbc6acc49a5495bde9ab03eb7199a67cde8c21224c6e13be"
