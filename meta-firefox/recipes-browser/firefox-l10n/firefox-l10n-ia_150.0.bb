# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4e8d41c0745c28ce711ea31bdde701077fc2bf1592ffc443eb7d20413ce79bea"
