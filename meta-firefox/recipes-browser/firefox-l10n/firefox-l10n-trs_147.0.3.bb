# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69948752e3620aa50a585f925ff2b641"
SRC_URI[sha256sum] = "e5ea6b13934527c0c539ea281d7120e5620b3450ae8ffc903184856d783f7332"
