# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b14f5e51f731cc73ffdf43acdedf740a"
SRC_URI[sha256sum] = "b2cefcaf3a3e45779789b6eb9957da626a4ac87efa0c1cb18bcf1a1453a4a0ea"
