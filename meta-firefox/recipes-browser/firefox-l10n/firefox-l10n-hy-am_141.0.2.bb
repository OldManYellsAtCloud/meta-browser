# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32c81717b33fe64e69a352f7f4b7e05f"
SRC_URI[sha256sum] = "94ef73514f95af122936c7ff553c29f94c878168a935c9d0bc5278143b4dd037"
