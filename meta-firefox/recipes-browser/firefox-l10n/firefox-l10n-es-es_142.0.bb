# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be471f0bc0ca0a74b87d8c2a52557f52"
SRC_URI[sha256sum] = "a72f3d69b48f0c1fc619069630a49a2f54597117ae1400e1bc195c79caf9b4a7"
